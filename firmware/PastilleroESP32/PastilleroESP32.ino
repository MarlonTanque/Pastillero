// PASTILLERO BADI: una sola fuente funcional; copia privada generada, no editada por separado.
#ifndef PASTILLERO_UNIFIED_SKETCH
#define PASTILLERO_UNIFIED_SKETCH

// ============================================================
// 1. LIBRERIAS
// ============================================================
#include <stdint.h>
#include <stdio.h>
#include <string.h>
#ifndef PASTILLERO_HOST_TEST
#include <Arduino.h>
// Lectura: control de pasos con velocidad/aceleración sin movimientos bloqueantes
#include <AccelStepper.h>
// Lectura: conexión inalámbrica del ESP32 en modo estación
#include <WiFi.h>
// Aprovisionamiento oficial: WPA2 SoftAP + protocomm Security1/PoP.
#include <network_provisioning/manager.h>
#include <network_provisioning/scheme_softap.h>
#include <esp_wifi.h>
#include <esp_random.h>
#include <atomic>
// Lectura: cliente TLS con validación de certificados raíz
#include <WiFiClientSecure.h>
// Lectura: métodos HTTP usados para las API REST de Firebase
#include <HTTPClient.h>
// Lectura: almacenamiento persistente NVS para sobrevivir a un reinicio
#include <Preferences.h>
// Lectura: serialización, lectura y comprobación de documentos JSON
#include <ArduinoJson.h>
// Lectura: reloj Unix sincronizado posteriormente mediante NTP
#include <time.h>
// Wire comunica el LCD por I2C desde una tarea separada, sin esperar dentro del motor.
#include <Wire.h>
// unique_ptr libera el arreglo temporal de 96 dosis al terminar la validación del JSON.
#include <memory>
// nothrow permite detectar falta de memoria y rechazar el plan de forma segura.
#include <new>

// ============================================================
// 2. CONFIGURACION WIFI
// ============================================================
// La versión pública usa marcadores. Los valores locales se introducen en private/firmware.local.json.
const char* WIFI_SSID = "INTRODUCIR_WIFI"; // CONFIG_LOCAL
const char* WIFI_PASSWORD = "INTRODUCIR_PASSWORD_WIFI"; // CONFIG_LOCAL

// ============================================================
// 3. CONFIGURACION FIREBASE Y CONFIANZA TLS
// ============================================================
// URL pública del proyecto dedicado. Nunca introducir claves Admin ni cuentas de servicio.
const char* FIREBASE_DATABASE_URL = "https://pastillerobadi-default-rtdb.firebaseio.com"; // CONFIG_LOCAL
const char* FIREBASE_API_KEY = "INTRODUCIR_FIREBASE_API_KEY"; // CONFIG_LOCAL
const char* DEVICE_EMAIL = "militar_tanque@hotmail.com"; // CONFIG_LOCAL
const char* DEVICE_PASSWORD = "Tanatos4020."; // CONFIG_LOCAL
const char* DEVICE_ID = "pastillero-01"; // CONFIG_LOCAL
// Raíces públicas necesarias para verificar HTTPS; se conserva íntegro el bloque anterior.
static const char GOOGLE_ROOTS[] PROGMEM = R"PEM(# Operating CA: Google Trust Services LLC
# Subject: C = US, O = Google Trust Services LLC, CN = GTS Root R1
# Issuer: C = US, O = Google Trust Services LLC, CN = GTS Root R1
# Label: "GTS Root R1"
# Serial: 0203E5936F31B01349886BA217
# MD5 Fingerprint: 05:FE:D0:BF:71:A8:A3:76:63:DA:01:E0:D8:52:DC:40
# SHA1 Fingerprint: E5:8C:1C:C4:91:3B:38:63:4B:E9:10:6E:E3:AD:8E:6B:9D:D9:81:4A
# SHA256 Fingerprint: D9:47:43:2A:BD:E7:B7:FA:90:FC:2E:6B:59:10:1B:12:80:E0:E1:C7:E4:E4:0F:A3:C6:88:7F:FF:57:A7:F4:CF
-----BEGIN CERTIFICATE-----
MIIFVzCCAz+gAwIBAgINAgPlk28xsBNJiGuiFzANBgkqhkiG9w0BAQwFADBHMQsw
CQYDVQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZpY2VzIExMQzEU
MBIGA1UEAxMLR1RTIFJvb3QgUjEwHhcNMTYwNjIyMDAwMDAwWhcNMzYwNjIyMDAw
MDAwWjBHMQswCQYDVQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZp
Y2VzIExMQzEUMBIGA1UEAxMLR1RTIFJvb3QgUjEwggIiMA0GCSqGSIb3DQEBAQUA
A4ICDwAwggIKAoICAQC2EQKLHuOhd5s73L+UPreVp0A8of2C+X0yBoJx9vaMf/vo
27xqLpeXo4xL+Sv2sfnOhB2x+cWX3u+58qPpvBKJXqeqUqv4IyfLpLGcY9vXmX7w
Cl7raKb0xlpHDU0QM+NOsROjyBhsS+z8CZDfnWQpJSMHobTSPS5g4M/SCYe7zUjw
TcLCeoiKu7rPWRnWr4+wB7CeMfGCwcDfLqZtbBkOtdh+JhpFAz2weaSUKK0Pfybl
qAj+lug8aJRT7oM6iCsVlgmy4HqMLnXWnOunVmSPlk9orj2XwoSPwLxAwAtcvfaH
szVsrBhQf4TgTM2S0yDpM7xSma8ytSmzJSq0SPly4cpk9+aCEI3oncKKiPo4Zor8
Y/kB+Xj9e1x3+naH+uzfsQ55lVe0vSbv1gHR6xYKu44LtcXFilWr06zqkUspzBmk
MiVOKvFlRNACzqrOSbTqn3yDsEB750Orp2yjj32JgfpMpf/VjsPOS+C12LOORc92
wO1AK/1TD7Cn1TsNsYqiA94xrcx36m97PtbfkSIS5r762DL8EGMUUXLeXdYWk70p
aDPvOmbsB4om3xPXV2V4J95eSRQAogB/mqghtqmxlbCluQ0WEdrHbEg8QOB+DVrN
VjzRlwW5y0vtOUucxD/SVRNuJLDWcfr0wbrM7Rv1/oFB2ACYPTrIrnqYNxgFlQID
AQABo0IwQDAOBgNVHQ8BAf8EBAMCAYYwDwYDVR0TAQH/BAUwAwEB/zAdBgNVHQ4E
FgQU5K8rJnEaK0gnhS9SZizv8IkTcT4wDQYJKoZIhvcNAQEMBQADggIBAJ+qQibb
C5u+/x6Wki4+omVKapi6Ist9wTrYggoGxval3sBOh2Z5ofmmWJyq+bXmYOfg6LEe
QkEzCzc9zolwFcq1JKjPa7XSQCGYzyI0zzvFIoTgxQ6KfF2I5DUkzps+GlQebtuy
h6f88/qBVRRiClmpIgUxPoLW7ttXNLwzldMXG+gnoot7TiYaelpkttGsN/H9oPM4
7HLwEXWdyzRSjeZ2axfG34arJ45JK3VmgRAhpuo+9K4l/3wV3s6MJT/KYnAK9y8J
ZgfIPxz88NtFMN9iiMG1D53Dn0reWVlHxYciNuaCp+0KueIHoI17eko8cdLiA6Ef
MgfdG+RCzgwARWGAtQsgWSl4vflVy2PFPEz0tv/bal8xa5meLMFrUKTX5hgUvYU/
Z6tGn6D/Qqc6f1zLXbBwHSs09dR2CQzreExZBfMzQsNhFRAbd03OIozUhfJFfbdT
6u9AWpQKXCBfTkBdYiJ23//OYb2MI3jSNwLgjt7RETeJ9r/tSQdirpLsQBqvFAnZ
0E6yove+7u7Y/9waLd64NnHi/Hm3lCXRSHNboTXns5lndcEZOitHTtNCjv0xyBZm
2tIMPNuzjsmhDYAPexZ3FL//2wmUspO8IFgV6dtxQ/PeEMMA3KgqlbbC1j+Qa3bb
bP6MvPJwNQzcmRk13NfIRmPVNnGuV/u3gm3c
-----END CERTIFICATE-----

# Operating CA: Google Trust Services LLC
# Subject: C = US, O = Google Trust Services LLC, CN = GTS Root R2
# Issuer: C = US, O = Google Trust Services LLC, CN = GTS Root R2
# Label: "GTS Root R2"
# Serial: 0203E5AEC58D04251AAB1125AA
# MD5 Fingerprint=1E:39:C0:53:E6:1E:29:82:0B:CA:52:55:36:5D:57:DC
# SHA1 Fingerprint=9A:44:49:76:32:DB:DE:FA:D0:BC:FB:5A:7B:17:BD:9E:56:09:24:94
# SHA256 Fingerprint=8D:25:CD:97:22:9D:BF:70:35:6B:DA:4E:B3:CC:73:40:31:E2:4C:F0:0F:AF:CF:D3:2D:C7:6E:B5:84:1C:7E:A8
-----BEGIN CERTIFICATE-----
MIIFVzCCAz+gAwIBAgINAgPlrsWNBCUaqxElqjANBgkqhkiG9w0BAQwFADBHMQsw
CQYDVQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZpY2VzIExMQzEU
MBIGA1UEAxMLR1RTIFJvb3QgUjIwHhcNMTYwNjIyMDAwMDAwWhcNMzYwNjIyMDAw
MDAwWjBHMQswCQYDVQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZp
Y2VzIExMQzEUMBIGA1UEAxMLR1RTIFJvb3QgUjIwggIiMA0GCSqGSIb3DQEBAQUA
A4ICDwAwggIKAoICAQDO3v2m++zsFDQ8BwZabFn3GTXd98GdVarTzTukk3LvCvpt
nfbwhYBboUhSnznFt+4orO/LdmgUud+tAWyZH8QiHZ/+cnfgLFuv5AS/T3KgGjSY
6Dlo7JUle3ah5mm5hRm9iYz+re026nO8/4Piy33B0s5Ks40FnotJk9/BW9BuXvAu
MC6C/Pq8tBcKSOWIm8Wba96wyrQD8Nr0kLhlZPdcTK3ofmZemde4wj7I0BOdre7k
RXuJVfeKH2JShBKzwkCX44ofR5GmdFrS+LFjKBC4swm4VndAoiaYecb+3yXuPuWg
f9RhD1FLPD+M2uFwdNjCaKH5wQzpoeJ/u1U8dgbuak7MkogwTZq9TwtImoS1mKPV
+3PBV2HdKFZ1E66HjucMUQkQdYhMvI35ezzUIkgfKtzra7tEscszcTJGr61K8Yzo
dDqs5xoic4DSMPclQsciOzsSrZYuxsN2B6ogtzVJV+mSSeh2FnIxZyuWfoqjx5RW
Ir9qS34BIbIjMt/kmkRtWVtd9QCgHJvGeJeNkP+byKq0rxFROV7Z+2et1VsRnTKa
G73VululycslaVNVJ1zgyjbLiGH7HrfQy+4W+9OmTN6SpdTi3/UGVN4unUu0kzCq
gc7dGtxRcw1PcOnlthYhGXmy5okLdWTK1au8CcEYof/UVKGFPP0UJAOyh9OktwID
AQABo0IwQDAOBgNVHQ8BAf8EBAMCAYYwDwYDVR0TAQH/BAUwAwEB/zAdBgNVHQ4E
FgQUu//KjiOfT5nK2+JopqUVJxce2Q4wDQYJKoZIhvcNAQEMBQADggIBAB/Kzt3H
vqGf2SdMC9wXmBFqiN495nFWcrKeGk6c1SuYJF2ba3uwM4IJvd8lRuqYnrYb/oM8
0mJhwQTtzuDFycgTE1XnqGOtjHsB/ncw4c5omwX4Eu55MaBBRTUoCnGkJE+M3DyC
B19m3H0Q/gxhswWV7uGugQ+o+MePTagjAiZrHYNSVc61LwDKgEDg4XSsYPWHgJ2u
NmSRXbBoGOqKYcl3qJfEycel/FVL8/B/uWU9J2jQzGv6U53hkRrJXRqWbTKH7QMg
yALOWr7Z6v2yTcQvG99fevX4i8buMTolUVVnjWQye+mew4K6Ki3pHrTgSAai/Gev
HyICc/sgCq+dVEuhzf9gR7A/Xe8bVr2XIZYtCtFenTgCR2y59PYjJbigapordwj6
xLEokCZYCDzifqrXPW+6MYgKBesntaFJ7qBFVHvmJ2WZICGoo7z7GJa7Um8M7YNR
TOlZ4iBgxcJlkoKM8xAfDoqXvneCbT+PHV28SSe9zE8P4c52hgQjxcCMElv924Sg
JPFI/2R80L5cFtHvma3AH/vLrrw4IgYmZNralw4/KBVEqE8AyvCazM90arQ+POuV
7LXTWtiBmelDGDfrs7vRWGJB82bSj6p4lVQgw1oudCvV0b4YacCs1aTPObpRhANl
6WLAYv7YTVWW4tAR+kg0Eeye7QUd5MjWHYbL
-----END CERTIFICATE-----

# Operating CA: Google Trust Services LLC
# Subject: C = US, O = Google Trust Services LLC, CN = GTS Root R3
# Issuer: C = US, O = Google Trust Services LLC, CN = GTS Root R3
# Label: "GTS Root R3"
# Serial: 0203E5B882EB20F825276D3D66
# MD5 Fingerprint: 3E:E7:9D:58:02:94:46:51:94:E5:E0:22:4A:8B:E7:73
# SHA1 Fingerprint: ED:E5:71:80:2B:C8:92:B9:5B:83:3C:D2:32:68:3F:09:CD:A0:1E:46
# SHA256 Fingerprint: 34:D8:A7:3E:E2:08:D9:BC:DB:0D:95:65:20:93:4B:4E:40:E6:94:82:59:6E:8B:6F:73:C8:42:6B:01:0A:6F:48
-----BEGIN CERTIFICATE-----
MIICCTCCAY6gAwIBAgINAgPluILrIPglJ209ZjAKBggqhkjOPQQDAzBHMQswCQYD
VQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZpY2VzIExMQzEUMBIG
A1UEAxMLR1RTIFJvb3QgUjMwHhcNMTYwNjIyMDAwMDAwWhcNMzYwNjIyMDAwMDAw
WjBHMQswCQYDVQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZpY2Vz
IExMQzEUMBIGA1UEAxMLR1RTIFJvb3QgUjMwdjAQBgcqhkjOPQIBBgUrgQQAIgNi
AAQfTzOHMymKoYTey8chWEGJ6ladK0uFxh1MJ7x/JlFyb+Kf1qPKzEUURout736G
jOyxfi//qXGdGIRFBEFVbivqJn+7kAHjSxm65FSWRQmx1WyRRK2EE46ajA2ADDL2
4CejQjBAMA4GA1UdDwEB/wQEAwIBhjAPBgNVHRMBAf8EBTADAQH/MB0GA1UdDgQW
BBTB8Sa6oC2uhYHP0/EqEr24Cmf9vDAKBggqhkjOPQQDAwNpADBmAjEA9uEglRR7
VKOQFhG/hMjqb2sXnh5GmCCbn9MN2azTL818+FsuVbu/3ZL3pAzcMeGiAjEA/Jdm
ZuVDFhOD3cffL74UOO0BzrEXGhF16b0DjyZ+hOXJYKaV11RZt+cRLInUue4X
-----END CERTIFICATE-----

# Operating CA: Google Trust Services LLC
# Subject: C = US, O = Google Trust Services LLC, CN = GTS Root R4
# Issuer: C = US, O = Google Trust Services LLC, CN = GTS Root R4
# Label: "GTS Root R4"
# Serial: 0203E5C068EF631A9C72905052
# MD5 Fingerprint=43:96:83:77:19:4D:76:B3:9D:65:52:E4:1D:22:A5:E8
# SHA1 Fingerprint=77:D3:03:67:B5:E0:0C:15:F6:0C:38:61:DF:7C:E1:3B:92:46:4D:47
# SHA256 Fingerprint=34:9D:FA:40:58:C5:E2:63:12:3B:39:8A:E7:95:57:3C:4E:13:13:C8:3F:E6:8F:93:55:6C:D5:E8:03:1B:3C:7D
-----BEGIN CERTIFICATE-----
MIICCTCCAY6gAwIBAgINAgPlwGjvYxqccpBQUjAKBggqhkjOPQQDAzBHMQswCQYD
VQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZpY2VzIExMQzEUMBIG
A1UEAxMLR1RTIFJvb3QgUjQwHhcNMTYwNjIyMDAwMDAwWhcNMzYwNjIyMDAwMDAw
WjBHMQswCQYDVQQGEwJVUzEiMCAGA1UEChMZR29vZ2xlIFRydXN0IFNlcnZpY2Vz
IExMQzEUMBIGA1UEAxMLR1RTIFJvb3QgUjQwdjAQBgcqhkjOPQIBBgUrgQQAIgNi
AATzdHOnaItgrkO4NcWBMHtLSZ37wWHO5t5GvWvVYRg1rkDdc/eJkTBa6zzuhXyi
QHY7qca4R9gq55KRanPpsXI5nymfopjTX15YhmUPoYRlBtHci8nHc8iMai/lxKvR
HYqjQjBAMA4GA1UdDwEB/wQEAwIBhjAPBgNVHRMBAf8EBTADAQH/MB0GA1UdDgQW
BBSATNbrdP9JNqPV2Py1PsVq8JQdjDAKBggqhkjOPQQDAwNpADBmAjEA6ED/g94D
9J+uHXqnLrmvT/aDHQ4thQEd0dlq7A/Cr8deVl5c1RxYIigL9zC2L7F8AjEA8GE8
p/SgguMh1YQdc4acLa/KNJvxn7kjNuK8YAOdgLOaVsjh4rsUecrNIdSUtUlD
-----END CERTIFICATE-----

# Operating CA: Google Trust Services LLC
# Subject: OU = GlobalSign ECC Root CA - R4, O = GlobalSign, CN = GlobalSign
# Issuer: OU = GlobalSign ECC Root CA - R4, O = GlobalSign, CN = GlobalSign
# Label: "GlobalSign R4"
# Serial: 0203E57EF53F93FDA50921B2A6
# MD5 Fingerprint: 26:29:F8:6D:E1:88:BF:A2:65:7F:AA:C4:CD:0F:7F:FC
# SHA1 Fingerprint: 6B:A0:B0:98:E1:71:EF:5A:AD:FE:48:15:80:77:10:F4:BD:6F:0B:28
# SHA256 Fingerprint: B0:85:D7:0B:96:4F:19:1A:73:E4:AF:0D:54:AE:7A:0E:07:AA:FD:AF:9B:71:DD:08:62:13:8A:B7:32:5A:24:A2
-----BEGIN CERTIFICATE-----
MIIB3DCCAYOgAwIBAgINAgPlfvU/k/2lCSGypjAKBggqhkjOPQQDAjBQMSQwIgYD
VQQLExtHbG9iYWxTaWduIEVDQyBSb290IENBIC0gUjQxEzARBgNVBAoTCkdsb2Jh
bFNpZ24xEzARBgNVBAMTCkdsb2JhbFNpZ24wHhcNMTIxMTEzMDAwMDAwWhcNMzgw
MTE5MDMxNDA3WjBQMSQwIgYDVQQLExtHbG9iYWxTaWduIEVDQyBSb290IENBIC0g
UjQxEzARBgNVBAoTCkdsb2JhbFNpZ24xEzARBgNVBAMTCkdsb2JhbFNpZ24wWTAT
BgcqhkjOPQIBBggqhkjOPQMBBwNCAAS4xnnTj2wlDp8uORkcA6SumuU5BwkWymOx
uYb4ilfBV85C+nOh92VC/x7BALJucw7/xyHlGKSq2XE/qNS5zowdo0IwQDAOBgNV
HQ8BAf8EBAMCAYYwDwYDVR0TAQH/BAUwAwEB/zAdBgNVHQ4EFgQUVLB7rUW44kB/
+wpu+74zyTyjhNUwCgYIKoZIzj0EAwIDRwAwRAIgIk90crlgr/HmnKAWBVBfw147
bmF0774BxL4YSFlhgjICICadVGNA3jdgUM/I2O2dgq43mLyjj0xMqTQrbO/7lZsm
-----END CERTIFICATE-----

# Operating CA: DigiCert
# Issuer: CN=DigiCert Assured ID Root G2 O=DigiCert Inc OU=www.digicert.com
# Subject: CN=DigiCert Assured ID Root G2 O=DigiCert Inc OU=www.digicert.com
# Label: "DigiCert Assured ID Root G2"
# Serial: 15385348160840213938643033620894905419
# MD5 Fingerprint: 92:38:b9:f8:63:24:82:65:2c:57:33:e6:fe:81:8f:9d
# SHA1 Fingerprint: a1:4b:48:d9:43:ee:0a:0e:40:90:4f:3c:e0:a4:c0:91:93:51:5d:3f
# SHA256 Fingerprint: 7d:05:eb:b6:82:33:9f:8c:94:51:ee:09:4e:eb:fe:fa:79:53:a1:14:ed:b2:f4:49:49:45:2f:ab:7d:2f:c1:85
-----BEGIN CERTIFICATE-----
MIIDljCCAn6gAwIBAgIQC5McOtY5Z+pnI7/Dr5r0SzANBgkqhkiG9w0BAQsFADBl
MQswCQYDVQQGEwJVUzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3
d3cuZGlnaWNlcnQuY29tMSQwIgYDVQQDExtEaWdpQ2VydCBBc3N1cmVkIElEIFJv
b3QgRzIwHhcNMTMwODAxMTIwMDAwWhcNMzgwMTE1MTIwMDAwWjBlMQswCQYDVQQG
EwJVUzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3d3cuZGlnaWNl
cnQuY29tMSQwIgYDVQQDExtEaWdpQ2VydCBBc3N1cmVkIElEIFJvb3QgRzIwggEi
MA0GCSqGSIb3DQEBAQUAA4IBDwAwggEKAoIBAQDZ5ygvUj82ckmIkzTz+GoeMVSA
n61UQbVH35ao1K+ALbkKz3X9iaV9JPrjIgwrvJUXCzO/GU1BBpAAvQxNEP4Htecc
biJVMWWXvdMX0h5i89vqbFCMP4QMls+3ywPgym2hFEwbid3tALBSfK+RbLE4E9Hp
EgjAALAcKxHad3A2m67OeYfcgnDmCXRwVWmvo2ifv922ebPynXApVfSr/5Vh88lA
bx3RvpO704gqu52/clpWcTs/1PPRCv4o76Pu2ZmvA9OPYLfykqGxvYmJHzDNw6Yu
YjOuFgJ3RFrngQo8p0Quebg/BLxcoIfhG69Rjs3sLPr4/m3wOnyqi+RnlTGNAgMB
AAGjQjBAMA8GA1UdEwEB/wQFMAMBAf8wDgYDVR0PAQH/BAQDAgGGMB0GA1UdDgQW
BBTOw0q5mVXyuNtgv6l+vVa1lzan1jANBgkqhkiG9w0BAQsFAAOCAQEAyqVVjOPI
QW5pJ6d1Ee88hjZv0p3GeDgdaZaikmkuOGybfQTUiaWxMTeKySHMq2zNixya1r9I
0jJmwYrA8y8678Dj1JGG0VDjA9tzd29KOVPt3ibHtX2vK0LRdWLjSisCx1BL4Gni
lmwORGYQRI+tBev4eaymG+g3NJ1TyWGqolKvSnAWhsI6yLETcDbYz+70CjTVW0z9
B5yiutkBclzzTcHdDrEcDcRjvq30FPuJ7KJBDkzMyFdA0G4Dqs0MjomZmWzwPDCv
ON9vvKO+KSAnq3T/EyJ43pdSVR6DtVQgA+6uwE9W3jfMw3+qBCe703e4YtsXfJwo
IhNzbM8m9Yop5w==
-----END CERTIFICATE-----

# Operating CA: DigiCert
# Issuer: CN=DigiCert Assured ID Root G3 O=DigiCert Inc OU=www.digicert.com
# Subject: CN=DigiCert Assured ID Root G3 O=DigiCert Inc OU=www.digicert.com
# Label: "DigiCert Assured ID Root G3"
# Serial: 15459312981008553731928384953135426796
# MD5 Fingerprint: 7c:7f:65:31:0c:81:df:8d:ba:3e:99:e2:5c:ad:6e:fb
# SHA1 Fingerprint: f5:17:a2:4f:9a:48:c6:c9:f8:a2:00:26:9f:dc:0f:48:2c:ab:30:89
# SHA256 Fingerprint: 7e:37:cb:8b:4c:47:09:0c:ab:36:55:1b:a6:f4:5d:b8:40:68:0f:ba:16:6a:95:2d:b1:00:71:7f:43:05:3f:c2
-----BEGIN CERTIFICATE-----
MIICRjCCAc2gAwIBAgIQC6Fa+h3foLVJRK/NJKBs7DAKBggqhkjOPQQDAzBlMQsw
CQYDVQQGEwJVUzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3d3cu
ZGlnaWNlcnQuY29tMSQwIgYDVQQDExtEaWdpQ2VydCBBc3N1cmVkIElEIFJvb3Qg
RzMwHhcNMTMwODAxMTIwMDAwWhcNMzgwMTE1MTIwMDAwWjBlMQswCQYDVQQGEwJV
UzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3d3cuZGlnaWNlcnQu
Y29tMSQwIgYDVQQDExtEaWdpQ2VydCBBc3N1cmVkIElEIFJvb3QgRzMwdjAQBgcq
hkjOPQIBBgUrgQQAIgNiAAQZ57ysRGXtzbg/WPuNsVepRC0FFfLvC/8QdJ+1YlJf
Zn4f5dwbRXkLzMZTCp2NXQLZqVneAlr2lSoOjThKiknGvMYDOAdfVdp+CW7if17Q
RSAPWXYQ1qAk8C3eNvJsKTmjQjBAMA8GA1UdEwEB/wQFMAMBAf8wDgYDVR0PAQH/
BAQDAgGGMB0GA1UdDgQWBBTL0L2p4ZgFUaFNN6KDec6NHSrkhDAKBggqhkjOPQQD
AwNnADBkAjAlpIFFAmsSS3V0T8gj43DydXLefInwz5FyYZ5eEJJZVrmDxxDnOOlY
JjZ91eQ0hjkCMHw2U/Aw5WJjOpnitqM7mzT6HtoQknFekROn3aRukswy1vUhZscv
6pZjamVFkpUBtA==
-----END CERTIFICATE-----


# Operating CA: DigiCert
# Issuer: CN=DigiCert Global Root G2 O=DigiCert Inc OU=www.digicert.com
# Subject: CN=DigiCert Global Root G2 O=DigiCert Inc OU=www.digicert.com
# Label: "DigiCert Global Root G2"
# Serial: 4293743540046975378534879503202253541
# MD5 Fingerprint: e4:a6:8a:c8:54:ac:52:42:46:0a:fd:72:48:1b:2a:44
# SHA1 Fingerprint: df:3c:24:f9:bf:d6:66:76:1b:26:80:73:fe:06:d1:cc:8d:4f:82:a4
# SHA256 Fingerprint: cb:3c:cb:b7:60:31:e5:e0:13:8f:8d:d3:9a:23:f9:de:47:ff:c3:5e:43:c1:14:4c:ea:27:d4:6a:5a:b1:cb:5f
-----BEGIN CERTIFICATE-----
MIIDjjCCAnagAwIBAgIQAzrx5qcRqaC7KGSxHQn65TANBgkqhkiG9w0BAQsFADBh
MQswCQYDVQQGEwJVUzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3
d3cuZGlnaWNlcnQuY29tMSAwHgYDVQQDExdEaWdpQ2VydCBHbG9iYWwgUm9vdCBH
MjAeFw0xMzA4MDExMjAwMDBaFw0zODAxMTUxMjAwMDBaMGExCzAJBgNVBAYTAlVT
MRUwEwYDVQQKEwxEaWdpQ2VydCBJbmMxGTAXBgNVBAsTEHd3dy5kaWdpY2VydC5j
b20xIDAeBgNVBAMTF0RpZ2lDZXJ0IEdsb2JhbCBSb290IEcyMIIBIjANBgkqhkiG
9w0BAQEFAAOCAQ8AMIIBCgKCAQEAuzfNNNx7a8myaJCtSnX/RrohCgiN9RlUyfuI
2/Ou8jqJkTx65qsGGmvPrC3oXgkkRLpimn7Wo6h+4FR1IAWsULecYxpsMNzaHxmx
1x7e/dfgy5SDN67sH0NO3Xss0r0upS/kqbitOtSZpLYl6ZtrAGCSYP9PIUkY92eQ
q2EGnI/yuum06ZIya7XzV+hdG82MHauVBJVJ8zUtluNJbd134/tJS7SsVQepj5Wz
tCO7TG1F8PapspUwtP1MVYwnSlcUfIKdzXOS0xZKBgyMUNGPHgm+F6HmIcr9g+UQ
vIOlCsRnKPZzFBQ9RnbDhxSJITRNrw9FDKZJobq7nMWxM4MphQIDAQABo0IwQDAP
BgNVHRMBAf8EBTADAQH/MA4GA1UdDwEB/wQEAwIBhjAdBgNVHQ4EFgQUTiJUIBiV
5uNu5g/6+rkS7QYXjzkwDQYJKoZIhvcNAQELBQADggEBAGBnKJRvDkhj6zHd6mcY
1Yl9PMWLSn/pvtsrF9+wX3N3KjITOYFnQoQj8kVnNeyIv/iPsGEMNKSuIEyExtv4
NeF22d+mQrvHRAiGfzZ0JFrabA0UWTW98kndth/Jsw1HKj2ZL7tcu7XUIOGZX1NG
Fdtom/DzMNU+MeKNhJ7jitralj41E6Vf8PlwUHBHQRFXGU7Aj64GxJUTFy8bJZ91
8rGOmaFvE7FBcf6IKshPECBV1/MUReXgRPTqh5Uykw7+U0b6LJ3/iyK5S9kJRaTe
pLiaWN0bfVKfjllDiIGknibVb63dDcY3fe0Dkhvld1927jyNxF1WW6LZZm6zNTfl
MrY=
-----END CERTIFICATE-----

# Operating CA: DigiCert
# Issuer: CN=DigiCert Global Root G3 O=DigiCert Inc OU=www.digicert.com
# Subject: CN=DigiCert Global Root G3 O=DigiCert Inc OU=www.digicert.com
# Label: "DigiCert Global Root G3"
# Serial: 7089244469030293291760083333884364146
# MD5 Fingerprint: f5:5d:a4:50:a5:fb:28:7e:1e:0f:0d:cc:96:57:56:ca
# SHA1 Fingerprint: 7e:04:de:89:6a:3e:66:6d:00:e6:87:d3:3f:fa:d9:3b:e8:3d:34:9e
# SHA256 Fingerprint: 31:ad:66:48:f8:10:41:38:c7:38:f3:9e:a4:32:01:33:39:3e:3a:18:cc:02:29:6e:f9:7c:2a:c9:ef:67:31:d0
-----BEGIN CERTIFICATE-----
MIICPzCCAcWgAwIBAgIQBVVWvPJepDU1w6QP1atFcjAKBggqhkjOPQQDAzBhMQsw
CQYDVQQGEwJVUzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3d3cu
ZGlnaWNlcnQuY29tMSAwHgYDVQQDExdEaWdpQ2VydCBHbG9iYWwgUm9vdCBHMzAe
Fw0xMzA4MDExMjAwMDBaFw0zODAxMTUxMjAwMDBaMGExCzAJBgNVBAYTAlVTMRUw
EwYDVQQKEwxEaWdpQ2VydCBJbmMxGTAXBgNVBAsTEHd3dy5kaWdpY2VydC5jb20x
IDAeBgNVBAMTF0RpZ2lDZXJ0IEdsb2JhbCBSb290IEczMHYwEAYHKoZIzj0CAQYF
K4EEACIDYgAE3afZu4q4C/sLfyHS8L6+c/MzXRq8NOrexpu80JX28MzQC7phW1FG
fp4tn+6OYwwX7Adw9c+ELkCDnOg/QW07rdOkFFk2eJ0DQ+4QE2xy3q6Ip6FrtUPO
Z9wj/wMco+I+o0IwQDAPBgNVHRMBAf8EBTADAQH/MA4GA1UdDwEB/wQEAwIBhjAd
BgNVHQ4EFgQUs9tIpPmhxdiuNkHMEWNpYim8S8YwCgYIKoZIzj0EAwMDaAAwZQIx
AK288mw/EkrRLTnDCgmXc/SINoyIJ7vmiI1Qhadj+Z4y3maTD/HMsQmP3Wyr+mt/
oAIwOWZbwmSNuJ5Q3KjVSaLtx9zRSX8XAbjIho9OjIgrqJqpisXRAL34VOKa5Vt8
sycX
-----END CERTIFICATE-----


# Operating CA: DigiCert
# Issuer: CN=DigiCert Trusted Root G4 O=DigiCert Inc OU=www.digicert.com
# Subject: CN=DigiCert Trusted Root G4 O=DigiCert Inc OU=www.digicert.com
# Label: "DigiCert Trusted Root G4"
# Serial: 7451500558977370777930084869016614236
# MD5 Fingerprint: 78:f2:fc:aa:60:1f:2f:b4:eb:c9:37:ba:53:2e:75:49
# SHA1 Fingerprint: dd:fb:16:cd:49:31:c9:73:a2:03:7d:3f:c8:3a:4d:7d:77:5d:05:e4
# SHA256 Fingerprint: 55:2f:7b:dc:f1:a7:af:9e:6c:e6:72:01:7f:4f:12:ab:f7:72:40:c7:8e:76:1a:c2:03:d1:d9:d2:0a:c8:99:88
-----BEGIN CERTIFICATE-----
MIIFkDCCA3igAwIBAgIQBZsbV56OITLiOQe9p3d1XDANBgkqhkiG9w0BAQwFADBi
MQswCQYDVQQGEwJVUzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3
d3cuZGlnaWNlcnQuY29tMSEwHwYDVQQDExhEaWdpQ2VydCBUcnVzdGVkIFJvb3Qg
RzQwHhcNMTMwODAxMTIwMDAwWhcNMzgwMTE1MTIwMDAwWjBiMQswCQYDVQQGEwJV
UzEVMBMGA1UEChMMRGlnaUNlcnQgSW5jMRkwFwYDVQQLExB3d3cuZGlnaWNlcnQu
Y29tMSEwHwYDVQQDExhEaWdpQ2VydCBUcnVzdGVkIFJvb3QgRzQwggIiMA0GCSqG
SIb3DQEBAQUAA4ICDwAwggIKAoICAQC/5pBzaN675F1KPDAiMGkz7MKnJS7JIT3y
ithZwuEppz1Yq3aaza57G4QNxDAf8xukOBbrVsaXbR2rsnnyyhHS5F/WBTxSD1If
xp4VpX6+n6lXFllVcq9ok3DCsrp1mWpzMpTREEQQLt+C8weE5nQ7bXHiLQwb7iDV
ySAdYyktzuxeTsiT+CFhmzTrBcZe7FsavOvJz82sNEBfsXpm7nfISKhmV1efVFiO
DCu3T6cw2Vbuyntd463JT17lNecxy9qTXtyOj4DatpGYQJB5w3jHtrHEtWoYOAMQ
jdjUN6QuBX2I9YI+EJFwq1WCQTLX2wRzKm6RAXwhTNS8rhsDdV14Ztk6MUSaM0C/
CNdaSaTC5qmgZ92kJ7yhTzm1EVgX9yRcRo9k98FpiHaYdj1ZXUJ2h4mXaXpI8OCi
EhtmmnTK3kse5w5jrubU75KSOp493ADkRSWJtppEGSt+wJS00mFt6zPZxd9LBADM
fRyVw4/3IbKyEbe7f/LVjHAsQWCqsWMYRJUadmJ+9oCw++hkpjPRiQfhvbfmQ6QY
uKZ3AeEPlAwhHbJUKSWJbOUOUlFHdL4mrLZBdd56rF+NP8m800ERElvlEFDrMcXK
chYiCd98THU/Y+whX8QgUWtvsauGi0/C1kVfnSD8oR7FwI+isX4KJpn15GkvmB0t
9dmpsh3lGwIDAQABo0IwQDAPBgNVHRMBAf8EBTADAQH/MA4GA1UdDwEB/wQEAwIB
hjAdBgNVHQ4EFgQU7NfjgtJxXWRM3y5nP+e6mK4cD08wDQYJKoZIhvcNAQEMBQAD
ggIBALth2X2pbL4XxJEbw6GiAI3jZGgPVs93rnD5/ZpKmbnJeFwMDF/k5hQpVgs2
SV1EY+CtnJYYZhsjDT156W1r1lT40jzBQ0CuHVD1UvyQO7uYmWlrx8GnqGikJ9yd
+SeuMIW59mdNOj6PWTkiU0TryF0Dyu1Qen1iIQqAyHNm0aAFYF/opbSnr6j3bTWc
fFqK1qI4mfN4i/RN0iAL3gTujJtHgXINwBQy7zBZLq7gcfJW5GqXb5JQbZaNaHqa
sjYUegbyJLkJEVDXCLG4iXqEI2FCKeWjzaIgQdfRnGTZ6iahixTXTBmyUEFxPT9N
cCOGDErcgdLMMpSEDQgJlxxPwO5rIHQw0uA5NBCFIRUBCOhVMt5xSdkoF1BN5r5N
0XWs0Mr7QbhDparTwwVETyw2m+L64kW4I1NsBm9nVX9GtUw/bihaeSbSpKhil9Ie
4u1Ki7wb/UdKDd9nZn6yW0HQO+T0O/QEY+nvwlQAUaCKKsnOeMzV6ocEGLPOr0mI
r/OSmbaz5mEP0oUA51Aa5BuVnRmhuZyxm7EAHu/QD09CbMkKvO5D+jpxpchNJqU1
/YldvIViHTLSoCtU7ZpXwdv6EM8Zt4tKG48BtieVU+i2iW1bvGjUI+iLUaJW+fCm
gKDWHrO8Dw9TdSmq6hN35N6MgSGtBxBHEa2HPQfRdbzP82Z+
-----END CERTIFICATE-----

# Operating CA: GlobalSign
# Issuer: CN=GlobalSign O=GlobalSign OU=GlobalSign Root CA - R3
# Subject: CN=GlobalSign O=GlobalSign OU=GlobalSign Root CA - R3
# Label: "GlobalSign Root CA - R3"
# Serial: 4835703278459759426209954
# MD5 Fingerprint: c5:df:b8:49:ca:05:13:55:ee:2d:ba:1a:c3:3e:b0:28
# SHA1 Fingerprint: d6:9b:56:11:48:f0:1c:77:c5:45:78:c1:09:26:df:5b:85:69:76:ad
# SHA256 Fingerprint: cb:b5:22:d7:b7:f1:27:ad:6a:01:13:86:5b:df:1c:d4:10:2e:7d:07:59:af:63:5a:7c:f4:72:0d:c9:63:c5:3b
-----BEGIN CERTIFICATE-----
MIIDXzCCAkegAwIBAgILBAAAAAABIVhTCKIwDQYJKoZIhvcNAQELBQAwTDEgMB4G
A1UECxMXR2xvYmFsU2lnbiBSb290IENBIC0gUjMxEzARBgNVBAoTCkdsb2JhbFNp
Z24xEzARBgNVBAMTCkdsb2JhbFNpZ24wHhcNMDkwMzE4MTAwMDAwWhcNMjkwMzE4
MTAwMDAwWjBMMSAwHgYDVQQLExdHbG9iYWxTaWduIFJvb3QgQ0EgLSBSMzETMBEG
A1UEChMKR2xvYmFsU2lnbjETMBEGA1UEAxMKR2xvYmFsU2lnbjCCASIwDQYJKoZI
hvcNAQEBBQADggEPADCCAQoCggEBAMwldpB5BngiFvXAg7aEyiie/QV2EcWtiHL8
RgJDx7KKnQRfJMsuS+FggkbhUqsMgUdwbN1k0ev1LKMPgj0MK66X17YUhhB5uzsT
gHeMCOFJ0mpiLx9e+pZo34knlTifBtc+ycsmWQ1z3rDI6SYOgxXG71uL0gRgykmm
KPZpO/bLyCiR5Z2KYVc3rHQU3HTgOu5yLy6c+9C7v/U9AOEGM+iCK65TpjoWc4zd
QQ4gOsC0p6Hpsk+QLjJg6VfLuQSSaGjlOCZgdbKfd/+RFO+uIEn8rUAVSNECMWEZ
XriX7613t2Saer9fwRPvm2L7DWzgVGkWqQPabumDk3F2xmmFghcCAwEAAaNCMEAw
DgYDVR0PAQH/BAQDAgEGMA8GA1UdEwEB/wQFMAMBAf8wHQYDVR0OBBYEFI/wS3+o
LkUkrk1Q+mOai97i3Ru8MA0GCSqGSIb3DQEBCwUAA4IBAQBLQNvAUKr+yAzv95ZU
RUm7lgAJQayzE4aGKAczymvmdLm6AC2upArT9fHxD4q/c2dKg8dEe3jgr25sbwMp
jjM5RcOO5LlXbKr8EpbsU8Yt5CRsuZRj+9xTaGdWPoO4zzUhw8lo/s7awlOqzJCK
6fBdRoyV3XpYKBovHd7NADdBj+1EbddTKJd+82cEHhXXipa0095MJ6RMG3NzdvQX
mcIfeg7jLQitChws/zyrVQ4PkX4268NXSb7hLi18YIvDQVETI53O9zJrlAGomecs
Mx86OyXShkDOOyyGeMlhLxS67ttVb9+E7gUJTb0o2HLO02JQZR7rkpeDMdmztcpH
WD9f
-----END CERTIFICATE-----

# Operating CA: GlobalSign
# Issuer: CN=GlobalSign O=GlobalSign OU=GlobalSign ECC Root CA - R5
# Subject: CN=GlobalSign O=GlobalSign OU=GlobalSign ECC Root CA - R5
# Label: "GlobalSign ECC Root CA - R5"
# Serial: 32785792099990507226680698011560947931244
# MD5 Fingerprint: 9f:ad:3b:1c:02:1e:8a:ba:17:74:38:81:0c:a2:bc:08
# SHA1 Fingerprint: 1f:24:c6:30:cd:a4:18:ef:20:69:ff:ad:4f:dd:5f:46:3a:1b:69:aa
# SHA256 Fingerprint: 17:9f:bc:14:8a:3d:d0:0f:d2:4e:a1:34:58:cc:43:bf:a7:f5:9c:81:82:d7:83:a5:13:f6:eb:ec:10:0c:89:24
-----BEGIN CERTIFICATE-----
MIICHjCCAaSgAwIBAgIRYFlJ4CYuu1X5CneKcflK2GwwCgYIKoZIzj0EAwMwUDEk
MCIGA1UECxMbR2xvYmFsU2lnbiBFQ0MgUm9vdCBDQSAtIFI1MRMwEQYDVQQKEwpH
bG9iYWxTaWduMRMwEQYDVQQDEwpHbG9iYWxTaWduMB4XDTEyMTExMzAwMDAwMFoX
DTM4MDExOTAzMTQwN1owUDEkMCIGA1UECxMbR2xvYmFsU2lnbiBFQ0MgUm9vdCBD
QSAtIFI1MRMwEQYDVQQKEwpHbG9iYWxTaWduMRMwEQYDVQQDEwpHbG9iYWxTaWdu
MHYwEAYHKoZIzj0CAQYFK4EEACIDYgAER0UOlvt9Xb/pOdEh+J8LttV7HpI6SFkc
8GIxLcB6KP4ap1yztsyX50XUWPrRd21DosCHZTQKH3rd6zwzocWdTaRvQZU4f8ke
hOvRnkmSh5SHDDqFSmafnVmTTZdhBoZKo0IwQDAOBgNVHQ8BAf8EBAMCAQYwDwYD
VR0TAQH/BAUwAwEB/zAdBgNVHQ4EFgQUPeYpSJvqB8ohREom3m7e0oPQn1kwCgYI
KoZIzj0EAwMDaAAwZQIxAOVpEslu28YxuglB4Zf4+/2a4n0Sye18ZNPLBSWLVtmg
515dTguDnFt2KaAJJiFqYgIwcdK1j1zqO+F4CYWodZI7yFz9SO8NdCKoCOJuxUnO
xwy8p2Fp8fc74SrL+SvzZpA3
-----END CERTIFICATE-----

# Operating CA: GlobalSign
# Issuer: CN=GlobalSign O=GlobalSign OU=GlobalSign Root CA - R6
# Subject: CN=GlobalSign O=GlobalSign OU=GlobalSign Root CA - R6
# Label: "GlobalSign Root CA - R6"
# Serial: 1417766617973444989252670301619537
# MD5 Fingerprint: 4f:dd:07:e4:d4:22:64:39:1e:0c:37:42:ea:d1:c6:ae
# SHA1 Fingerprint: 80:94:64:0e:b5:a7:a1:ca:11:9c:1f:dd:d5:9f:81:02:63:a7:fb:d1
# SHA256 Fingerprint: 2c:ab:ea:fe:37:d0:6c:a2:2a:ba:73:91:c0:03:3d:25:98:29:52:c4:53:64:73:49:76:3a:3a:b5:ad:6c:cf:69
-----BEGIN CERTIFICATE-----
MIIFgzCCA2ugAwIBAgIORea7A4Mzw4VlSOb/RVEwDQYJKoZIhvcNAQEMBQAwTDEg
MB4GA1UECxMXR2xvYmFsU2lnbiBSb290IENBIC0gUjYxEzARBgNVBAoTCkdsb2Jh
bFNpZ24xEzARBgNVBAMTCkdsb2JhbFNpZ24wHhcNMTQxMjEwMDAwMDAwWhcNMzQx
MjEwMDAwMDAwWjBMMSAwHgYDVQQLExdHbG9iYWxTaWduIFJvb3QgQ0EgLSBSNjET
MBEGA1UEChMKR2xvYmFsU2lnbjETMBEGA1UEAxMKR2xvYmFsU2lnbjCCAiIwDQYJ
KoZIhvcNAQEBBQADggIPADCCAgoCggIBAJUH6HPKZvnsFMp7PPcNCPG0RQssgrRI
xutbPK6DuEGSMxSkb3/pKszGsIhrxbaJ0cay/xTOURQh7ErdG1rG1ofuTToVBu1k
ZguSgMpE3nOUTvOniX9PeGMIyBJQbUJmL025eShNUhqKGoC3GYEOfsSKvGRMIRxD
aNc9PIrFsmbVkJq3MQbFvuJtMgamHvm566qjuL++gmNQ0PAYid/kD3n16qIfKtJw
LnvnvJO7bVPiSHyMEAc4/2ayd2F+4OqMPKq0pPbzlUoSB239jLKJz9CgYXfIWHSw
1CM69106yqLbnQneXUQtkPGBzVeS+n68UARjNN9rkxi+azayOeSsJDa38O+2HBNX
k7besvjihbdzorg1qkXy4J02oW9UivFyVm4uiMVRQkQVlO6jxTiWm05OWgtH8wY2
SXcwvHE35absIQh1/OZhFj931dmRl4QKbNQCTXTAFO39OfuD8l4UoQSwC+n+7o/h
bguyCLNhZglqsQY6ZZZZwPA1/cnaKI0aEYdwgQqomnUdnjqGBQCe24DWJfncBZ4n
WUx2OVvq+aWh2IMP0f/fMBH5hc8zSPXKbWQULHpYT9NLCEnFlWQaYw55PfWzjMpY
rZxCRXluDocZXFSxZba/jJvcE+kNb7gu3GduyYsRtYQUigAZcIN5kZeR1Bonvzce
MgfYFGM8KEyvAgMBAAGjYzBhMA4GA1UdDwEB/wQEAwIBBjAPBgNVHRMBAf8EBTAD
AQH/MB0GA1UdDgQWBBSubAWjkxPioufi1xzWx/B/yGdToDAfBgNVHSMEGDAWgBSu
bAWjkxPioufi1xzWx/B/yGdToDANBgkqhkiG9w0BAQwFAAOCAgEAgyXt6NH9lVLN
nsAEoJFp5lzQhN7craJP6Ed41mWYqVuoPId8AorRbrcWc+ZfwFSY1XS+wc3iEZGt
Ixg93eFyRJa0lV7Ae46ZeBZDE1ZXs6KzO7V33EByrKPrmzU+sQghoefEQzd5Mr61
55wsTLxDKZmOMNOsIeDjHfrYBzN2VAAiKrlNIC5waNrlU/yDXNOd8v9EDERm8tLj
vUYAGm0CuiVdjaExUd1URhxN25mW7xocBFymFe944Hn+Xds+qkxV/ZoVqW/hpvvf
cDDpw+5CRu3CkwWJ+n1jez/QcYF8AOiYrg54NMMl+68KnyBr3TsTjxKM4kEaSHpz
oHdpx7Zcf4LIHv5YGygrqGytXm3ABdJ7t+uA/iU3/gKbaKxCXcPu9czc8FB10jZp
nOZ7BN9uBmm23goJSFmH63sUYHpkqmlD75HHTOwY3WzvUy2MmeFe8nI+z1TIvWfs
pA9MRf/TuTAjB0yPEL+GltmZWrSZVxykzLsViVO6LAUP5MSeGbEYNNVMnbrt9x+v
JJUEeKgDu+6B5dpffItKoZB0JaezPkvILFa9x8jvOOJckvB595yEunQtYQEgfn7R
8k8HWV+LLUNS60YMlOH1Zkd5d9VUWx+tJDfLRVpOoERIyNiwmcUVhAn21klJwGW4
5hpxbqCo8YLoRT5s1gLXCmeDBVrJpBA=
-----END CERTIFICATE-----

# Note: "GlobalSign Root CA - R7" not added on purpose. It is P-521.

# Operating CA: GoDaddy
# Issuer: CN=Go Daddy Root Certificate Authority - G2 O=GoDaddy.com, Inc.
# Subject: CN=Go Daddy Root Certificate Authority - G2 O=GoDaddy.com, Inc.
# Label: "Go Daddy Root Certificate Authority - G2"
# Serial: 0
# MD5 Fingerprint: 80:3a:bc:22:c1:e6:fb:8d:9b:3b:27:4a:32:1b:9a:01
# SHA1 Fingerprint: 47:be:ab:c9:22:ea:e8:0e:78:78:34:62:a7:9f:45:c2:54:fd:e6:8b
# SHA256 Fingerprint: 45:14:0b:32:47:eb:9c:c8:c5:b4:f0:d7:b5:30:91:f7:32:92:08:9e:6e:5a:63:e2:74:9d:d3:ac:a9:19:8e:da
-----BEGIN CERTIFICATE-----
MIIDxTCCAq2gAwIBAgIBADANBgkqhkiG9w0BAQsFADCBgzELMAkGA1UEBhMCVVMx
EDAOBgNVBAgTB0FyaXpvbmExEzARBgNVBAcTClNjb3R0c2RhbGUxGjAYBgNVBAoT
EUdvRGFkZHkuY29tLCBJbmMuMTEwLwYDVQQDEyhHbyBEYWRkeSBSb290IENlcnRp
ZmljYXRlIEF1dGhvcml0eSAtIEcyMB4XDTA5MDkwMTAwMDAwMFoXDTM3MTIzMTIz
NTk1OVowgYMxCzAJBgNVBAYTAlVTMRAwDgYDVQQIEwdBcml6b25hMRMwEQYDVQQH
EwpTY290dHNkYWxlMRowGAYDVQQKExFHb0RhZGR5LmNvbSwgSW5jLjExMC8GA1UE
AxMoR28gRGFkZHkgUm9vdCBDZXJ0aWZpY2F0ZSBBdXRob3JpdHkgLSBHMjCCASIw
DQYJKoZIhvcNAQEBBQADggEPADCCAQoCggEBAL9xYgjx+lk09xvJGKP3gElY6SKD
E6bFIEMBO4Tx5oVJnyfq9oQbTqC023CYxzIBsQU+B07u9PpPL1kwIuerGVZr4oAH
/PMWdYA5UXvl+TW2dE6pjYIT5LY/qQOD+qK+ihVqf94Lw7YZFAXK6sOoBJQ7Rnwy
DfMAZiLIjWltNowRGLfTshxgtDj6AozO091GB94KPutdfMh8+7ArU6SSYmlRJQVh
GkSBjCypQ5Yj36w6gZoOKcUcqeldHraenjAKOc7xiID7S13MMuyFYkMlNAJWJwGR
tDtwKj9useiciAF9n9T521NtYJ2/LOdYq7hfRvzOxBsDPAnrSTFcaUaz4EcCAwEA
AaNCMEAwDwYDVR0TAQH/BAUwAwEB/zAOBgNVHQ8BAf8EBAMCAQYwHQYDVR0OBBYE
FDqahQcQZyi27/a9BUFuIMGU2g/eMA0GCSqGSIb3DQEBCwUAA4IBAQCZ21151fmX
WWcDYfF+OwYxdS2hII5PZYe096acvNjpL9DbWu7PdIxztDhC2gV7+AJ1uP2lsdeu
9tfeE8tTEH6KRtGX+rcuKxGrkLAngPnon1rpN5+r5N9ss4UXnT3ZJE95kTXWXwTr
gIOrmgIttRD02JDHBHNA7XIloKmf7J6raBKZV8aPEjoJpL1E/QYVN8Gb5DKj7Tjo
2GTzLH4U/ALqn83/B2gX2yKQOC16jdFU8WnjXzPKej17CuPKf1855eJ1usV2GDPO
LPAvTK33sefOT6jEm0pUBsV/fdUID+Ic/n4XuKxe9tQWskMJDE32p2u0mYRlynqI
4uJEvlz36hz1
-----END CERTIFICATE-----

# Operating CA: GoDaddy
# Issuer: CN=Starfield Root Certificate Authority - G2 O=Starfield Technologies, Inc.
# Subject: CN=Starfield Root Certificate Authority - G2 O=Starfield Technologies, Inc.
# Label: "Starfield Root Certificate Authority - G2"
# Serial: 0
# MD5 Fingerprint: d6:39:81:c6:52:7e:96:69:fc:fc:ca:66:ed:05:f2:96
# SHA1 Fingerprint: b5:1c:06:7c:ee:2b:0c:3d:f8:55:ab:2d:92:f4:fe:39:d4:e7:0f:0e
# SHA256 Fingerprint: 2c:e1:cb:0b:f9:d2:f9:e1:02:99:3f:be:21:51:52:c3:b2:dd:0c:ab:de:1c:68:e5:31:9b:83:91:54:db:b7:f5
-----BEGIN CERTIFICATE-----
MIID3TCCAsWgAwIBAgIBADANBgkqhkiG9w0BAQsFADCBjzELMAkGA1UEBhMCVVMx
EDAOBgNVBAgTB0FyaXpvbmExEzARBgNVBAcTClNjb3R0c2RhbGUxJTAjBgNVBAoT
HFN0YXJmaWVsZCBUZWNobm9sb2dpZXMsIEluYy4xMjAwBgNVBAMTKVN0YXJmaWVs
ZCBSb290IENlcnRpZmljYXRlIEF1dGhvcml0eSAtIEcyMB4XDTA5MDkwMTAwMDAw
MFoXDTM3MTIzMTIzNTk1OVowgY8xCzAJBgNVBAYTAlVTMRAwDgYDVQQIEwdBcml6
b25hMRMwEQYDVQQHEwpTY290dHNkYWxlMSUwIwYDVQQKExxTdGFyZmllbGQgVGVj
aG5vbG9naWVzLCBJbmMuMTIwMAYDVQQDEylTdGFyZmllbGQgUm9vdCBDZXJ0aWZp
Y2F0ZSBBdXRob3JpdHkgLSBHMjCCASIwDQYJKoZIhvcNAQEBBQADggEPADCCAQoC
ggEBAL3twQP89o/8ArFvW59I2Z154qK3A2FWGMNHttfKPTUuiUP3oWmb3ooa/RMg
nLRJdzIpVv257IzdIvpy3Cdhl+72WoTsbhm5iSzchFvVdPtrX8WJpRBSiUZV9Lh1
HOZ/5FSuS/hVclcCGfgXcVnrHigHdMWdSL5stPSksPNkN3mSwOxGXn/hbVNMYq/N
Hwtjuzqd+/x5AJhhdM8mgkBj87JyahkNmcrUDnXMN/uLicFZ8WJ/X7NfZTD4p7dN
dloedl40wOiWVpmKs/B/pM293DIxfJHP4F8R+GuqSVzRmZTRouNjWwl2tVZi4Ut0
HZbUJtQIBFnQmA4O5t78w+wfkPECAwEAAaNCMEAwDwYDVR0TAQH/BAUwAwEB/zAO
BgNVHQ8BAf8EBAMCAQYwHQYDVR0OBBYEFHwMMh+n2TB/xH1oo2Kooc6rB1snMA0G
CSqGSIb3DQEBCwUAA4IBAQARWfolTwNvlJk7mh+ChTnUdgWUXuEok21iXQnCoKjU
sHU48TRqneSfioYmUeYs0cYtbpUgSpIB7LiKZ3sx4mcujJUDJi5DnUox9g61DLu3
4jd/IroAow57UvtruzvE03lRTs2Q9GcHGcg8RnoNAX3FWOdt5oUwF5okxBDgBPfg
8n/Uqgr/Qh037ZTlZFkSIHc40zI+OIF1lnP6aI+xy84fxez6nH7PfrHxBy22/L/K
pL/QlwVKvOoYKAKQvVR4CSFx09F9HdkWsKlhPdAKACL8x3vLCWRFCztAgfd9fDL1
mMpYjn0q7pBZc2T5NnReJaH1ZgUufzkVqSr7UIuOhWn0
-----END CERTIFICATE-----

# Operating CA: Sectigo
# Issuer: CN=COMODO ECC Certification Authority O=COMODO CA Limited
# Subject: CN=COMODO ECC Certification Authority O=COMODO CA Limited
# Label: "COMODO ECC Certification Authority"
# Serial: 41578283867086692638256921589707938090
# MD5 Fingerprint: 7c:62:ff:74:9d:31:53:5e:68:4a:d5:78:aa:1e:bf:23
# SHA1 Fingerprint: 9f:74:4e:9f:2b:4d:ba:ec:0f:31:2c:50:b6:56:3b:8e:2d:93:c3:11
# SHA256 Fingerprint: 17:93:92:7a:06:14:54:97:89:ad:ce:2f:8f:34:f7:f0:b6:6d:0f:3a:e3:a3:b8:4d:21:ec:15:db:ba:4f:ad:c7
-----BEGIN CERTIFICATE-----
MIICiTCCAg+gAwIBAgIQH0evqmIAcFBUTAGem2OZKjAKBggqhkjOPQQDAzCBhTEL
MAkGA1UEBhMCR0IxGzAZBgNVBAgTEkdyZWF0ZXIgTWFuY2hlc3RlcjEQMA4GA1UE
BxMHU2FsZm9yZDEaMBgGA1UEChMRQ09NT0RPIENBIExpbWl0ZWQxKzApBgNVBAMT
IkNPTU9ETyBFQ0MgQ2VydGlmaWNhdGlvbiBBdXRob3JpdHkwHhcNMDgwMzA2MDAw
MDAwWhcNMzgwMTE4MjM1OTU5WjCBhTELMAkGA1UEBhMCR0IxGzAZBgNVBAgTEkdy
ZWF0ZXIgTWFuY2hlc3RlcjEQMA4GA1UEBxMHU2FsZm9yZDEaMBgGA1UEChMRQ09N
T0RPIENBIExpbWl0ZWQxKzApBgNVBAMTIkNPTU9ETyBFQ0MgQ2VydGlmaWNhdGlv
biBBdXRob3JpdHkwdjAQBgcqhkjOPQIBBgUrgQQAIgNiAAQDR3svdcmCFYX7deSR
FtSrYpn1PlILBs5BAH+X4QokPB0BBO490o0JlwzgdeT6+3eKKvUDYEs2ixYjFq0J
cfRK9ChQtP6IHG4/bC8vCVlbpVsLM5niwz2J+Wos77LTBumjQjBAMB0GA1UdDgQW
BBR1cacZSBm8nZ3qQUfflMRId5nTeTAOBgNVHQ8BAf8EBAMCAQYwDwYDVR0TAQH/
BAUwAwEB/zAKBggqhkjOPQQDAwNoADBlAjEA7wNbeqy3eApyt4jf/7VGFAkK+qDm
fQjGGoe9GKhzvSbKYAydzpmfz1wPMOG+FDHqAjAU9JM8SaczepBGR7NjfRObTrdv
GDeAU/7dIOA1mjbRxwG55tzd8/8dLDoWV9mSOdY=
-----END CERTIFICATE-----

# Operating CA: Sectigo
# Issuer: CN=COMODO RSA Certification Authority O=COMODO CA Limited
# Subject: CN=COMODO RSA Certification Authority O=COMODO CA Limited
# Label: "COMODO RSA Certification Authority"
# Serial: 101909084537582093308941363524873193117
# MD5 Fingerprint: 1b:31:b0:71:40:36:cc:14:36:91:ad:c4:3e:fd:ec:18
# SHA1 Fingerprint: af:e5:d2:44:a8:d1:19:42:30:ff:47:9f:e2:f8:97:bb:cd:7a:8c:b4
# SHA256 Fingerprint: 52:f0:e1:c4:e5:8e:c6:29:29:1b:60:31:7f:07:46:71:b8:5d:7e:a8:0d:5b:07:27:34:63:53:4b:32:b4:02:34
-----BEGIN CERTIFICATE-----
MIIF2DCCA8CgAwIBAgIQTKr5yttjb+Af907YWwOGnTANBgkqhkiG9w0BAQwFADCB
hTELMAkGA1UEBhMCR0IxGzAZBgNVBAgTEkdyZWF0ZXIgTWFuY2hlc3RlcjEQMA4G
A1UEBxMHU2FsZm9yZDEaMBgGA1UEChMRQ09NT0RPIENBIExpbWl0ZWQxKzApBgNV
BAMTIkNPTU9ETyBSU0EgQ2VydGlmaWNhdGlvbiBBdXRob3JpdHkwHhcNMTAwMTE5
MDAwMDAwWhcNMzgwMTE4MjM1OTU5WjCBhTELMAkGA1UEBhMCR0IxGzAZBgNVBAgT
EkdyZWF0ZXIgTWFuY2hlc3RlcjEQMA4GA1UEBxMHU2FsZm9yZDEaMBgGA1UEChMR
Q09NT0RPIENBIExpbWl0ZWQxKzApBgNVBAMTIkNPTU9ETyBSU0EgQ2VydGlmaWNh
dGlvbiBBdXRob3JpdHkwggIiMA0GCSqGSIb3DQEBAQUAA4ICDwAwggIKAoICAQCR
6FSS0gpWsawNJN3Fz0RndJkrN6N9I3AAcbxT38T6KhKPS38QVr2fcHK3YX/JSw8X
pz3jsARh7v8Rl8f0hj4K+j5c+ZPmNHrZFGvnnLOFoIJ6dq9xkNfs/Q36nGz637CC
9BR++b7Epi9Pf5l/tfxnQ3K9DADWietrLNPtj5gcFKt+5eNu/Nio5JIk2kNrYrhV
/erBvGy2i/MOjZrkm2xpmfh4SDBF1a3hDTxFYPwyllEnvGfDyi62a+pGx8cgoLEf
Zd5ICLqkTqnyg0Y3hOvozIFIQ2dOciqbXL1MGyiKXCJ7tKuY2e7gUYPDCUZObT6Z
+pUX2nwzV0E8jVHtC7ZcryxjGt9XyD+86V3Em69FmeKjWiS0uqlWPc9vqv9JWL7w
qP/0uK3pN/u6uPQLOvnoQ0IeidiEyxPx2bvhiWC4jChWrBQdnArncevPDt09qZah
SL0896+1DSJMwBGB7FY79tOi4lu3sgQiUpWAk2nojkxl8ZEDLXB0AuqLZxUpaVIC
u9ffUGpVRr+goyhhf3DQw6KqLCGqR84onAZFdr+CGCe01a60y1Dma/RMhnEw6abf
Fobg2P9A3fvQQoh/ozM6LlweQRGBY84YcWsr7KaKtzFcOmpH4MN5WdYgGq/yapiq
crxXStJLnbsQ/LBMQeXtHT1eKJ2czL+zUdqnR+WEUwIDAQABo0IwQDAdBgNVHQ4E
FgQUu69+Aj36pvE8hI6t7jiY7NkyMtQwDgYDVR0PAQH/BAQDAgEGMA8GA1UdEwEB
/wQFMAMBAf8wDQYJKoZIhvcNAQEMBQADggIBAArx1UaEt65Ru2yyTUEUAJNMnMvl
wFTPoCWOAvn9sKIN9SCYPBMtrFaisNZ+EZLpLrqeLppysb0ZRGxhNaKatBYSaVqM
4dc+pBroLwP0rmEdEBsqpIt6xf4FpuHA1sj+nq6PK7o9mfjYcwlYRm6mnPTXJ9OV
2jeDchzTc+CiR5kDOF3VSXkAKRzH7JsgHAckaVd4sjn8OoSgtZx8jb8uk2Intzna
FxiuvTwJaP+EmzzV1gsD41eeFPfR60/IvYcjt7ZJQ3mFXLrrkguhxuhoqEwWsRqZ
CuhTLJK7oQkYdQxlqHvLI7cawiiFwxv/0Cti76R7CZGYZ4wUAc1oBmpjIXUDgIiK
boHGhfKppC3n9KUkEEeDys30jXlYsQab5xoq2Z0B15R97QNKyvDb6KkBPvVWmcke
jkk9u+UJueBPSZI9FoJAzMxZxuY67RIuaTxslbH9qh17f4a+Hg4yRvv7E491f0yL
S0Zj/gA0QHDBw7mh3aZw4gSzQbzpgJHqZJx64SIDqZxubw5lT2yHh17zbqD5daWb
QOhTsiedSrnAdyGN/4fy3ryM7xfft0kL0fJuMAsaDk527RH89elWsn2/x20Kk4yl
0MC2Hb46TpSi125sC8KKfPog88Tk5c0NqMuRkrF8hey1FGlmDoLnzc7ILaZRfyHB
NVOFBkpdn627G190
-----END CERTIFICATE-----

# Operating CA: Sectigo
# Issuer: CN=USERTrust ECC Certification Authority O=The USERTRUST Network
# Subject: CN=USERTrust ECC Certification Authority O=The USERTRUST Network
# Label: "USERTrust ECC Certification Authority"
# Serial: 123013823720199481456569720443997572134
# MD5 Fingerprint: fa:68:bc:d9:b5:7f:ad:fd:c9:1d:06:83:28:cc:24:c1
# SHA1 Fingerprint: d1:cb:ca:5d:b2:d5:2a:7f:69:3b:67:4d:e5:f0:5a:1d:0c:95:7d:f0
# SHA256 Fingerprint: 4f:f4:60:d5:4b:9c:86:da:bf:bc:fc:57:12:e0:40:0d:2b:ed:3f:bc:4d:4f:bd:aa:86:e0:6a:dc:d2:a9:ad:7a
-----BEGIN CERTIFICATE-----
MIICjzCCAhWgAwIBAgIQXIuZxVqUxdJxVt7NiYDMJjAKBggqhkjOPQQDAzCBiDEL
MAkGA1UEBhMCVVMxEzARBgNVBAgTCk5ldyBKZXJzZXkxFDASBgNVBAcTC0plcnNl
eSBDaXR5MR4wHAYDVQQKExVUaGUgVVNFUlRSVVNUIE5ldHdvcmsxLjAsBgNVBAMT
JVVTRVJUcnVzdCBFQ0MgQ2VydGlmaWNhdGlvbiBBdXRob3JpdHkwHhcNMTAwMjAx
MDAwMDAwWhcNMzgwMTE4MjM1OTU5WjCBiDELMAkGA1UEBhMCVVMxEzARBgNVBAgT
Ck5ldyBKZXJzZXkxFDASBgNVBAcTC0plcnNleSBDaXR5MR4wHAYDVQQKExVUaGUg
VVNFUlRSVVNUIE5ldHdvcmsxLjAsBgNVBAMTJVVTRVJUcnVzdCBFQ0MgQ2VydGlm
aWNhdGlvbiBBdXRob3JpdHkwdjAQBgcqhkjOPQIBBgUrgQQAIgNiAAQarFRaqflo
I+d61SRvU8Za2EurxtW20eZzca7dnNYMYf3boIkDuAUU7FfO7l0/4iGzzvfUinng
o4N+LZfQYcTxmdwlkWOrfzCjtHDix6EznPO/LlxTsV+zfTJ/ijTjeXmjQjBAMB0G
A1UdDgQWBBQ64QmG1M8ZwpZ2dEl23OA1xmNjmjAOBgNVHQ8BAf8EBAMCAQYwDwYD
VR0TAQH/BAUwAwEB/zAKBggqhkjOPQQDAwNoADBlAjA2Z6EWCNzklwBBHU6+4WMB
zzuqQhFkoJ2UOQIReVx7Hfpkue4WQrO/isIJxOzksU0CMQDpKmFHjFJKS04YcPbW
RNZu9YO6bVi9JNlWSOrvxKJGgYhqOkbRqZtNyWHa0V1Xahg=
-----END CERTIFICATE-----

# Operating CA: Sectigo
# Issuer: CN=USERTrust RSA Certification Authority O=The USERTRUST Network
# Subject: CN=USERTrust RSA Certification Authority O=The USERTRUST Network
# Label: "USERTrust RSA Certification Authority"
# Serial: 2645093764781058787591871645665788717
# MD5 Fingerprint: 1b:fe:69:d1:91:b7:19:33:a3:72:a8:0f:e1:55:e5:b5
# SHA1 Fingerprint: 2b:8f:1b:57:33:0d:bb:a2:d0:7a:6c:51:f7:0e:e9:0d:da:b9:ad:8e
# SHA256 Fingerprint: e7:93:c9:b0:2f:d8:aa:13:e2:1c:31:22:8a:cc:b0:81:19:64:3b:74:9c:89:89:64:b1:74:6d:46:c3:d4:cb:d2
-----BEGIN CERTIFICATE-----
MIIF3jCCA8agAwIBAgIQAf1tMPyjylGoG7xkDjUDLTANBgkqhkiG9w0BAQwFADCB
iDELMAkGA1UEBhMCVVMxEzARBgNVBAgTCk5ldyBKZXJzZXkxFDASBgNVBAcTC0pl
cnNleSBDaXR5MR4wHAYDVQQKExVUaGUgVVNFUlRSVVNUIE5ldHdvcmsxLjAsBgNV
BAMTJVVTRVJUcnVzdCBSU0EgQ2VydGlmaWNhdGlvbiBBdXRob3JpdHkwHhcNMTAw
MjAxMDAwMDAwWhcNMzgwMTE4MjM1OTU5WjCBiDELMAkGA1UEBhMCVVMxEzARBgNV
BAgTCk5ldyBKZXJzZXkxFDASBgNVBAcTC0plcnNleSBDaXR5MR4wHAYDVQQKExVU
aGUgVVNFUlRSVVNUIE5ldHdvcmsxLjAsBgNVBAMTJVVTRVJUcnVzdCBSU0EgQ2Vy
dGlmaWNhdGlvbiBBdXRob3JpdHkwggIiMA0GCSqGSIb3DQEBAQUAA4ICDwAwggIK
AoICAQCAEmUXNg7D2wiz0KxXDXbtzSfTTK1Qg2HiqiBNCS1kCdzOiZ/MPans9s/B
3PHTsdZ7NygRK0faOca8Ohm0X6a9fZ2jY0K2dvKpOyuR+OJv0OwWIJAJPuLodMkY
tJHUYmTbf6MG8YgYapAiPLz+E/CHFHv25B+O1ORRxhFnRghRy4YUVD+8M/5+bJz/
Fp0YvVGONaanZshyZ9shZrHUm3gDwFA66Mzw3LyeTP6vBZY1H1dat//O+T23LLb2
VN3I5xI6Ta5MirdcmrS3ID3KfyI0rn47aGYBROcBTkZTmzNg95S+UzeQc0PzMsNT
79uq/nROacdrjGCT3sTHDN/hMq7MkztReJVni+49Vv4M0GkPGw/zJSZrM233bkf6
c0Plfg6lZrEpfDKEY1WJxA3Bk1QwGROs0303p+tdOmw1XNtB1xLaqUkL39iAigmT
Yo61Zs8liM2EuLE/pDkP2QKe6xJMlXzzawWpXhaDzLhn4ugTncxbgtNMs+1b/97l
c6wjOy0AvzVVdAlJ2ElYGn+SNuZRkg7zJn0cTRe8yexDJtC/QV9AqURE9JnnV4ee
UB9XVKg+/XRjL7FQZQnmWEIuQxpMtPAlR1n6BB6T1CZGSlCBst6+eLf8ZxXhyVeE
Hg9j1uliutZfVS7qXMYoCAQlObgOK6nyTJccBz8NUvXt7y+CDwIDAQABo0IwQDAd
BgNVHQ4EFgQUU3m/WqorSs9UgOHYm8Cd8rIDZsswDgYDVR0PAQH/BAQDAgEGMA8G
A1UdEwEB/wQFMAMBAf8wDQYJKoZIhvcNAQEMBQADggIBAFzUfA3P9wF9QZllDHPF
Up/L+M+ZBn8b2kMVn54CVVeWFPFSPCeHlCjtHzoBN6J2/FNQwISbxmtOuowhT6KO
VWKR82kV2LyI48SqC/3vqOlLVSoGIG1VeCkZ7l8wXEskEVX/JJpuXior7gtNn3/3
ATiUFJVDBwn7YKnuHKsSjKCaXqeYalltiz8I+8jRRa8YFWSQEg9zKC7F4iRO/Fjs
8PRF/iKz6y+O0tlFYQXBl2+odnKPi4w2r78NBc5xjeambx9spnFixdjQg3IM8WcR
iQycE0xyNN+81XHfqnHd4blsjDwSXWXavVcStkNr/+XeTWYRUc+ZruwXtuhxkYze
Sf7dNXGiFSeUHM9h4ya7b6NnJSFd5t0dCy5oGzuCr+yDZ4XUmFF0sbmZgIn/f3gZ
XHlKYC6SQK5MNyosycdiyA5d9zZbyuAlJQG03RoHnHcAP9Dc1ew91Pq7P8yF1m9/
qS3fuQL39ZeatTXaw2ewh0qpKJ4jjv9cJ2vhsE/zB+4ALtRZh8tSQZXq9EfX7mRB
VXyNWQKV3WKdwrnuWih0hKWbt5DHDAff9Yk2dDLWKMGwsAvgnEzDHNb842m1R0aB
L6KCq9NjRHDEjf8tM7qtj3u1cIiuPhnPQCjY/MiQu12ZIvVS5ljFH4gxQ+6IHdfG
jjxDah2nGN59PRbxYvnKkKj9
-----END CERTIFICATE-----

# Operating CA: SSL.com
# Issuer: CN=SSL.com Client RSA Root CA 2022 O=SSL Corporation
# Subject: CN=SSL.com Client RSA Root CA 2022 O=SSL Corporation
# Label: SSL.com Client RSA Root CA 2022
# Serial Number: 76AFEE88931545B650539B809CA4DF9A
# SHA-1 Fingerprint: AA:59:70:E5:20:32:9F:CB:D0:D5:79:9F:FB:1B:82:1D:FD:1F:79:65
# SHA-256 Fingerprint: 1D:4C:A4:A2:AB:21:D0:09:36:59:80:4F:C0:EB:21:75:A6:17:27:9B:56:A2:47:52:45:C9:51:7A:FE:B5:91:53
-----BEGIN CERTIFICATE-----
MIIFjzCCA3egAwIBAgIQdq/uiJMVRbZQU5uAnKTfmjANBgkqhkiG9w0BAQsFADBR
MQswCQYDVQQGEwJVUzEYMBYGA1UECgwPU1NMIENvcnBvcmF0aW9uMSgwJgYDVQQD
DB9TU0wuY29tIENsaWVudCBSU0EgUm9vdCBDQSAyMDIyMB4XDTIyMDgyNTE2MzEw
N1oXDTQ2MDgxOTE2MzEwNlowUTELMAkGA1UEBhMCVVMxGDAWBgNVBAoMD1NTTCBD
b3Jwb3JhdGlvbjEoMCYGA1UEAwwfU1NMLmNvbSBDbGllbnQgUlNBIFJvb3QgQ0Eg
MjAyMjCCAiIwDQYJKoZIhvcNAQEBBQADggIPADCCAgoCggIBALhY20Yw+8k/48jw
ATM04tpIqBjpIG6a1wHh1SmPMLQjauTLYrC+4p8gvT5UoDlox4Y3ZnQGBu90K9rc
n4SpUi+Q0u5+fPulIq1vcEZnlj0p1KO7VnsUBFnBIWNEHrIfElyQh2UNiPYeiCLi
Y1S78zb41n/c2v8pNanGbg5pWz/YvoKHFXBdsMdcEg9jpjjNz3O5ww6JJjcbP2Ic
MmnRm9n/VZAx3rFj3c/FdHf874ghU78AMRomLAAwpV9s4+T2AIrKmIecdAN6i2bs
fv2jjzUlXHils6T7PW2pivBsiIKL/UrQb+TXo7SONEk4vs5F5dIcyl7CNxSLzWZW
Mzed5WvsQ5JkoELadW/AFez5ab00uYp7+hb7Vf5SIOgEBFZWZfU3RJjIikbpt6y4
6L5ijlQ2W/c7cL9d7i26X95CGYbwf4vrCMvYvuoOQkKgNnNXF+0y6tCN6Acbm5no
xJpiBA5I9zwSuvdYwZqM6cewIzZWNB3LbNq6B4Qd/dGsn+bCie/DuWwYs2mHV1+1
DDhbpyEkKjunNJGetFTqKE/TwaOL5OYr1fKdv5thACLd1ktEHz9dVv7enHjMmVuq
5L2620NLrUwmTKNNNIpsdDYT22L8m7IFgf+uPwzN9hui9DnnyvVMXPtUdzWAWsAS
oRMBM2c9nYGhqfWFJFiIeOf042hVAgMBAAGjYzBhMA8GA1UdEwEB/wQFMAMBAf8w
HwYDVR0jBBgwFoAU8DhClDSpPAB/Uu45pfdLDbxqfSMwHQYDVR0OBBYEFPA4QpQ0
qTwAf1LuOaX3Sw28an0jMA4GA1UdDwEB/wQEAwIBhjANBgkqhkiG9w0BAQsFAAOC
AgEAmU/b8OrWEfoq/cirbeQOc2LSQp8V/nxwUj9kh4IxP0VALuEinwZmKfyW0y2N
tjjH2fMnwVkpoIz2cyQPKCLXTmHdE93bnzJSk/tPzOo4PJhqA6sWryHRQq59RSvq
xM+KWZ+CcHY6+GImyRCXWEAkpC25LymAJ+GJa3LKSQhxN1MF8YDO00IC0vzC0ZQG
7gfi9oPif5/nu1bDW7/dlZMJHiTBzybNraSuwrRp56q17TeU6d3RY4VrmnpKVnbc
GYUo1OTGpNi4lkF30LRZ8UYFh4cCH2m5ghjQQ9km2hpnqNZ1durybQ5C/4gmom6E
/n5iG/DGPe3AHGrHkda4ADdJm7mEBaHNbjHWROpTi7pTmB2hkIrphfgb8pNYw8jc
miZPPiDPT0PzEIx/EGF6NsqqC33Mn0dEWa6llcaZU+MHaz1JELAY/10OhUMUS+dr
00q1smBh3GlJAiNd6JJxw5yfRWd5HtwyhrqqVTxkbzK1EEAV3nJAeOBucLtu6wno
OdmsupJ13UPKugGVrRqBKzrw48UvDBhNEMauwO3+BVJ/GQXLqa81CAw4IuT+VuVT
Pr/k1rPZCMM91TMygSTFqeFlEbgyMzBxGEkdGkXGmhSKWDkobvPLUblJJmR4A8eR
EYOpuZA0tm+qBZ6FKFeZvn8nBkliTaH8CeErRglMFJtWj0U=
-----END CERTIFICATE-----

# Operating CA: SSL.com
# Issuer: CN=SSL.com Client ECC Root CA 2022 O=SSL Corporation
# Subject: CN=SSL.com Client ECC Root CA 2022 O=SSL Corporation
# Label: SSL.com Client ECC Root CA 2022
# Serial Number: 76F8481EAEF03C701FE03F25540183D5
# SHA-1 Fingerprint: 80:7B:1D:9D:65:72:3D:C7:56:F9:EC:C5:00:83:49:F6:F2:AC:F4:86
# SHA-256 Fingerprint: AD:7D:D5:8D:03:AE:DB:22:A3:0B:50:84:39:49:20:CE:12:23:0C:2D:80:17:AD:9B:81:AB:04:07:9B:DD:02:6B
-----BEGIN CERTIFICATE-----
MIICQDCCAcagAwIBAgIQdvhIHq7wPHAf4D8lVAGD1TAKBggqhkjOPQQDAzBRMQsw
CQYDVQQGEwJVUzEYMBYGA1UECgwPU1NMIENvcnBvcmF0aW9uMSgwJgYDVQQDDB9T
U0wuY29tIENsaWVudCBFQ0MgUm9vdCBDQSAyMDIyMB4XDTIyMDgyNTE2MzAzMloX
DTQ2MDgxOTE2MzAzMVowUTELMAkGA1UEBhMCVVMxGDAWBgNVBAoMD1NTTCBDb3Jw
b3JhdGlvbjEoMCYGA1UEAwwfU1NMLmNvbSBDbGllbnQgRUNDIFJvb3QgQ0EgMjAy
MjB2MBAGByqGSM49AgEGBSuBBAAiA2IABC1Tfp+LPrM2ulDizOvcuiaK04wGP2cP
7/UX5dSumkYqQQEHaedncfHCAzbG8CtSjs8UkmikPnBREmmNeKKCyikUwOSUIrJE
kmBvyASkZ9Wi0PPQ1+qOPA+60kBHkDTufaNjMGEwDwYDVR0TAQH/BAUwAwEB/zAf
BgNVHSMEGDAWgBS3/i1ixYFTzVIaL11goMNd+7IcHDAdBgNVHQ4EFgQUt/4tYsWB
U81SGi9dYKDDXfuyHBwwDgYDVR0PAQH/BAQDAgGGMAoGCCqGSM49BAMDA2gAMGUC
ME0HES0R+7kmwyHdcuEX/MHPFOpJznGHjtZT3BHNXVSKr9kt9IxR6rxmR+J/lYNg
ZQIxAIwhTE+75bBQ35BiSebMkdv4P11xkQiOT5LJf6Zc6hN+7W3E6MMqb1wR4aXz
alqaTQ==
-----END CERTIFICATE-----
)PEM";


// ============================================================
// 4. CONFIGURACION DE PINES Y MODO SIMULACION
// ============================================================
#ifndef PASTILLERO_DRY_RUN
// Lectura: Valor predeterminado seguro: el binario de simulación no habilita salidas ni lee sensores físicos.
#define PASTILLERO_DRY_RUN 1
#endif
// Lectura: Conserva PUL=25 y DIR=26 del original; 27 permite pull-up del botón y 34 es entrada analógica sin pull-up
// Lectura: interno.
constexpr int PIN_PUL = 25, PIN_DIR = 26, PIN_BUTTON = 27, PIN_OPTICAL = 34;
// Lectura: Salidas de avisador y LED; usar resistencias/etapa de potencia y niveles adecuados al componente real.
constexpr int PIN_BUZZER = 14, PIN_READY = 18, PIN_ALERT = 19;
constexpr int OPTICAL_THRESHOLD = 1800;  // Comprobar polaridad y umbral con el sensor real en la fase física autorizada.

// Periféricos V2: quedan bloqueados localmente hasta validar el montaje. Nunca se activan en DRY_RUN.
#ifndef PASTILLERO_LCD_AVAILABLE
#define PASTILLERO_LCD_AVAILABLE 0
#endif
#ifndef PASTILLERO_EXIT_AVAILABLE
#define PASTILLERO_EXIT_AVAILABLE 0
#endif
#ifndef PASTILLERO_SERVO_AVAILABLE
#define PASTILLERO_SERVO_AVAILABLE 0
#endif
#ifndef PASTILLERO_PUMP_AVAILABLE
#define PASTILLERO_PUMP_AVAILABLE 0
#endif
constexpr int PIN_SDA=21, PIN_SCL=22, PIN_EXIT=35, PIN_SERVO=13, PIN_PUMP=23;
constexpr uint8_t LCD_ADDRESS=0x27;
constexpr uint32_t SERVO_CLOSED_US=1000, SERVO_OPEN_US=2000;
// GPIO35 solo entrada: necesita la polarización externa apropiada. No conectar señales de 5 V al ESP32.

// Montaje confirmado: cinco espacios, cuatro de dosis y cero vacío de retorno.
constexpr int DEFAULT_POSITIONS = 5;

#endif // Solo Arduino: no se incluyen red ni GPIO en las pruebas de PC.

// ============================================================
// 5. CONSTANTES DEL MOTOR NEMA 17 Y TIEMPOS
// ============================================================
namespace pill {
#ifndef PASTILLERO_STEPS_PER_TURN
#define PASTILLERO_STEPS_PER_TURN 3200
#endif
// Lectura: Una vuelta depende del microstepping del TB6600: 3200 pulsos por defecto, no 3200
// grados.
constexpr long STEPS_PER_TURN = PASTILLERO_STEPS_PER_TURN;
static_assert(STEPS_PER_TURN > 0 && STEPS_PER_TURN % 4 == 0,
              "Steps must divide into four compartments");
// Perfil histórico de cuatro posiciones: 800 pasos. V2 calcula con positions=5 (640 pasos).
// setup() aplica DEFAULT_POSITIONS=5; esta constante conserva compatibilidad con pruebas V1.
constexpr long STEPS_PER_SLOT = STEPS_PER_TURN / 4;
static_assert(STEPS_PER_TURN % 5 == 0, "Steps must also divide into five positions");
// Lectura: Duraciones relativas: 2 s para entregar y 15 s de pausa en la secuencia manual.
constexpr uint32_t DROP_MS = 2000, INTERVAL_MS = 15000;
// Lectura: Cinco minutos contados desde scheduledAt; no desde el regreso del motor.
constexpr int64_t OMIT_MS = 300000;

// ============================================================
// 6. VARIABLES Y MODELOS DE SENSORES Y ACTUADORES
// ============================================================
// Lectura: Estados 0 a 7 en este orden: Android interpreta los mismos números en la telemetría.
enum class State { Idle, Outward, Drop, Returning, Awaiting, Alert, ManualGap, Fault };
// Estas políticas puras también se ejecutan en PC, sin GPIO ni red.
bool wifiSetupAllowed(State state, bool stopped) { return state == State::Idle && stopped; }
bool wifiSetupExpired(uint32_t now, uint32_t start) { return uint32_t(now - start) >= 300000; }
bool wifiButtonRequest(bool idle, bool pressed, uint32_t now, bool& armed, bool& timing, uint32_t& since) {
    if (!idle) { armed = timing = false; return false; }
    if (!pressed) { armed = true; timing = false; return false; }
    if (!armed) return false;
    if (!timing) { timing = true; since = now; }
    if (uint32_t(now - since) < 8000) return false;
    armed = timing = false;
    return true;
}

// Lectura: Contrato de movimiento y persistencia: permite probar el controlador en PC sin GPIO.
// Modelo V2 de periféricos: se prueba en PC sin bibliotecas Arduino ni escrituras GPIO.
struct PeripheralSettings {
    bool ledEnabled = true, buzzerEnabled = true;
    bool lcdEnabled = false, exitSensorEnabled = false, servoEnabled = false, pumpEnabled = false;
    uint32_t pumpDurationMs = 2000;
};
class Feedback {
   public:
    bool ready = false, alert = false, buzzer = false, servoOpen = false, pump = false;
    uint32_t pumpSince = 0;
    bool previousConfirmation = false;
    bool confirmationVisible = false;
    uint32_t confirmationSince = 0;
    void tick(State state, uint32_t ms, bool confirmedNow, const PeripheralSettings& p) {
        if (confirmedNow && !previousConfirmation) { confirmationVisible = true; confirmationSince = ms; }
        if (state != State::Idle || (confirmationVisible && uint32_t(ms - confirmationSince) >= 5000)) confirmationVisible = false;
        bool warning = state == State::Alert || state == State::Fault;
        ready = p.ledEnabled && state == State::Awaiting;
        alert = p.ledEnabled && warning;
        buzzer = p.buzzerEnabled && (warning || state == State::Awaiting) && ms % 1000 < 100;
        servoOpen = p.servoEnabled && state == State::Drop;
        if (!p.pumpEnabled || warning || uint32_t(ms - pumpSince) >= p.pumpDurationMs)
            pump = false;
        // La bomba solo puede empezar después de una confirmación física recién registrada.
        if (confirmedNow && !previousConfirmation && p.pumpEnabled && !warning && !pump) {
            pump = true;
            pumpSince = ms;
        }
        previousConfirmation = confirmedNow;
    }
    static void lcd(State state, int compartment, bool simulation, char* first, char* second,
                    const char* cause = nullptr) {
        const char* names[] = {"En espera",        "Dispensando",        "Entregando",
                               "Volviendo a cero", "Toma tu pastilla", "ALERTA: revisar",
                               "Pausa secuencia",  "FALLO: revisar"};
        const char* title = names[int(state)];
        if (state == State::Alert && cause) {
            if (!strcmp(cause, "NO_EXIT"))
                title = "Sin salida";
            else if (!strcmp(cause, "MISSED"))
                title = "Dosis omitida";
            else if (!strcmp(cause, "BLOCKED"))
                title = "Revisar blister";
            else if (!strcmp(cause, "RECOVERY"))
                title = "Reinicio: revisar";
        }
        strncpy(first, title, 16);
        first[16] = 0;
        // snprintf escribe como máximo 16 caracteres más terminador, compatible con LCD 16x2.
        snprintf(second, 17, "%s C%d", simulation ? "SIMULACION" : "PASTILLERO", compartment);
    }
};
class ExitDetector {
    bool initialized = false, raw = false, stable = false;
    uint32_t changed = 0;

   public:
    bool sample(bool blocked, uint32_t ms) {
        if (!initialized) {
            initialized = true;
            raw = stable = blocked;
            changed = ms;
            return false;
        }
        if (blocked != raw) {
            raw = blocked;
            changed = ms;
        }
        if (raw != stable && uint32_t(ms - changed) >= 10) {
            stable = raw;
            return stable;
        }
        return false;
    }
};

// ============================================================
// 7. VARIABLES DE HORARIOS, MEDICAMENTOS Y RESERVAS
// ============================================================
struct Dose {
    // Lectura: Identidad estable: hasta 36 caracteres y el terminador cero; {} inicia el arreglo
    // vacío.
    char id[37]{};
    // Lectura: Fecha Unix UTC en milisegundos; 64 bits evita desbordar las fechas actuales.
    int64_t scheduledAt = 0;
    // Posición útil de la dosis: 1..4 con cinco espacios; cero queda reservado al retorno.
    int compartment = 1;
    char medicationId[37]{};
};
// Un evento debe conservar su texto aunque Controller reutilice active para otra dosis.
// En ArduinoJson 7.3.2 un const char[N] se trata como literal estático. Convertirlo a
// const char* selecciona la copia de la cadena con su longitud real, sin compartir el arreglo.
// La plantilla permite probar EXACTAMENTE esta escritura JSON en PC, sin incluir Arduino/GPIO.
template <typename JsonObjectType>
inline void writeDoseEvent(JsonObjectType event, const Dose& dose, const char* kind,
                           int64_t actual, bool simulation) {
    event["doseId"] = static_cast<const char*>(dose.id);
    event["medicationId"] = static_cast<const char*>(dose.medicationId);
    event["type"] = kind;
    event["scheduledAt"] = dose.scheduledAt;
    event["actualAt"] = actual;
    event["compartment"] = dose.compartment;
    event["simulation"] = simulation;
}
// La clave reservada también debe copiarse: active.id se reutilizará en otra entrega.
template <typename JsonRootType>
inline void reserveDoseId(JsonRootType& snapshot, const Dose& dose) {
    snapshot["done"][static_cast<const char*>(dose.id)] = true;
}
constexpr size_t SNAPSHOT_MAX_BYTES = 48000;
enum class SnapshotSource { Fresh, LegacyString, Blob, Invalid };
// El formato nuevo tiene prioridad. Si su marcador existe pero falta el bloque, no se
// retrocede a una copia antigua que podría olvidar reservas de dosis ya ejecutadas.
template <typename Store>
inline SnapshotSource snapshotSource(Store& store) {
    if (store.isKey("snapshot-v2")) return SnapshotSource::Blob;
    if (store.getUChar("snapshot-ver", 0) != 0) return SnapshotSource::Invalid;
    return store.isKey("snapshot") ? SnapshotSource::LegacyString : SnapshotSource::Fresh;
}
// NVS limita una cadena a 4000 bytes: el JSON completo se guarda como blob, no putString.
// Preferences confirma cada escritura. La reserva solo se acepta tras bloque y marcador.
template <typename Store>
inline bool saveSnapshotBlob(Store& store, const char* data, size_t length) {
    if (!data || length == 0 || length > SNAPSHOT_MAX_BYTES) return false;
    if (store.putBytes("snapshot-v2", data, length) != length) return false;
    return store.putUChar("snapshot-ver", 2) == 1;
}
template <typename Store>
inline size_t snapshotBlobSize(Store& store) {
    size_t length = store.getBytesLength("snapshot-v2");
    return length > 0 && length <= SNAPSHOT_MAX_BYTES ? length : 0;
}
template <typename Store>
inline bool readSnapshotBlob(Store& store, char* data, size_t capacity, size_t length) {
    if (!data || length == 0 || length > SNAPSHOT_MAX_BYTES || capacity <= length) return false;
    if (store.getBytes("snapshot-v2", data, length) != length || memchr(data, 0, length))
        return false;
    data[length] = '\0';
    return true;
}

// ============================================================
// 8. VARIABLES DE CONTROL Y ESTADOS
// ============================================================
struct Port {
    // Lectura: Destructor virtual: al liberar un adaptador a través de Port se respeta su tipo
    // concreto.
    virtual ~Port() = default;
    // Lectura: Ordena un destino absoluto en pasos; =0 exige que el adaptador implemente la
    // operación.
    virtual void move(long position) = 0;
    // Lectura: Consulta si el destino terminó; el controlador no espera dentro de esta llamada.
    virtual bool reached() = 0;
    // Lectura: Consulta la reserva durable del ID para impedir otra entrega de la misma dosis.
    virtual bool handled(const char* id) = 0;
    // Guardar en memoria persistente ANTES de devolver true. STARTED reserva el identificador.
    virtual bool record(const Dose& dose, const char* type, int64_t actual) = 0;
};
class Controller {
   public:
    explicit Controller(Port& port) : io(port) {
    }
    // Lectura: El controlador arranca en reposo; aún debe calibrarse antes de mover.
    State state = State::Idle;
    // Lectura: Cada arranque exige confirmar el cero; la memoria no conoce la posición mecánica
    // real.
    bool calibrated = false;
    // Capacidad V2: 96 dosis. count indica las ocupadas; nunca se recorta un plan silenciosamente.
    Dose doses[96]{};
    int positions = 4;
    bool requireExit = false, exitDetected = false;
    const char* lastEvent = nullptr;
    int currentCompartment() const {
        return slot;
    }
    bool geometry(int value) {
        if ((value != 4 && value != 5) ||
            (busy() && state != State::Alert && state != State::Fault))
            return false;
        if (positions != value) {
            positions = value;
            calibrated = false;
        }
        return true;
    }
    int count = 0;
    // Lectura: Consulta de solo lectura: cualquier estado distinto de Idle impide iniciar otra
    // secuencia.
    bool busy() const {
        return state != State::Idle;
    }
    // Lectura: Inicia s únicamente en reposo y calibrado; ms es millis(), no una fecha UTC.
    bool manualStart(uint32_t ms) {
        if (busy() || !calibrated)
            return false;
        manual = true;
        slot = 1;
        beginMove(ms);
        return true;
    }
    // Lectura: Avanza una transición sin esperar: recibe tiempo relativo, fecha, presencia y botón
    // ya filtrado.
    void tick(uint32_t ms, int64_t epoch, bool blister, bool pressed, bool exitPulse = false) {
        if ((state == State::Outward || state == State::Drop || state == State::Returning) &&
            exitPulse)
            exitDetected = true;
        // Lectura: Fallo seguro: no se intenta dispensar mientras la persistencia o la
        // inicialización estén dañadas.
        if (state == State::Fault)
            return;
        if (state == State::Idle) {
            if (!io.reached())
                return;
            // Lectura: No evalúa horarios con un reloj aún no sincronizado; LL conserva el literal
            // en 64 bits.
            if (epoch < 1700000000000LL)
                return;
            // Lectura: Todavía no hay candidata; -1 evita confundir ausencia con el índice cero del
            // arreglo.
            int next = -1;
            for (int i = 0; i < count; ++i)
                // Lectura: Solo considera dosis vencidas cuyo ID no esté reservado; la línea
                // siguiente elige la más Lectura: antigua.
                if (!io.handled(doses[i].id) && doses[i].scheduledAt <= epoch &&
                    (next < 0 || doses[i].scheduledAt < doses[next].scheduledAt))
                    next = i;
            if (next < 0)
                return;
            // Lectura: Copia la candidata: la entrega en curso mantiene su identidad aunque luego
            // llegue otro plan.
            active = doses[next];
            // Lectura: Si ya venció el margen de cinco minutos, registra omisión en lugar de
            // iniciar una entrega Lectura: tardía.
            if (epoch - active.scheduledAt >= OMIT_MS) {
                log("MISSED", epoch);
                state = state == State::Fault ? state : State::Alert;
                return;
            }
            if (!calibrated || !io.reached())
                return;
            // Lectura: Sin presencia de blíster se registra BLOCKED y se pide revisión; no comienza
            // el giro.
            if (!blister) {
                log("BLOCKED", epoch);
                if (state != State::Fault)
                    state = State::Alert;
                return;
            }
            // Lectura: Reserva y persiste el ID antes de mover. Si falla, log deja el controlador
            // en Fault.
            if (!log("STARTED", epoch))
                return;
            manual = false;
            // Lectura: Un horario selecciona una sola posición; s ejecuta la secuencia manual
            // completa.
            slot = active.compartment;
            beginMove(ms);
            return;
        }
        // Lectura: Al llegar al compartimento cambia a entrega y empieza a medir su espera de dos
        // segundos.
        if (state == State::Outward && io.reached()) {
            state = State::Drop;
            since = ms;
            // Lectura: La resta unsigned tolera la vuelta de millis(); se comprueba el tiempo sin
            // detener loop().
        } else if (state == State::Drop && uint32_t(ms - since) >= DROP_MS) {
            // Lectura: Después de entregar solicita volver al cero previamente calibrado.
            io.move(0);
            state = State::Returning;
        } else if (state == State::Returning && io.reached()) {
            if (manual) {
                state = State::ManualGap;
                since = ms;
            } else if (requireExit && !exitDetected) {
                if (log("NO_EXIT", epoch)) {
                    state = State::Alert;
                    released = false;
                }
            } else {
                state = State::Awaiting;
                // Lectura: Exige soltar y volver a pulsar: un botón mantenido durante el giro no
                // confirma una toma.
                released = !pressed;
            }
        } else if (state == State::Awaiting) {
            if (!pressed)
                released = true;
            // Lectura: Si ya venció el margen de cinco minutos, registra omisión en lugar de
            // iniciar una entrega Lectura: tardía.
            if (epoch - active.scheduledAt >= OMIT_MS) {
                if (log("MISSED", epoch)) {
                    state = State::Alert;
                    released = false;
                }
                // Lectura: Solo una pulsación posterior a la liberación puede registrar CONFIRMED.
            } else if (pressed && released) {
                if (log("CONFIRMED", epoch))
                    state = State::Idle;
            }
            // Lectura: Reconocer una alerta vuelve al reposo; no transforma una omisión en una toma
            // confirmada.
        } else if (state == State::Alert) {
            if (!pressed)
                released = true;
            if (pressed && released) {
                state = State::Idle;
                released = false;
            }
        } else if (state == State::ManualGap && uint32_t(ms - since) >= INTERVAL_MS) {
            // Tras la pausa termina s o avanza al siguiente compartimento útil: con cinco
            // espacios recorre 1→0, 2→0, 3→0, 4→0; el espacio cero siempre queda vacío.
            if (++slot >= positions) {
                manual = false;
                state = State::Idle;
            } else
                beginMove(ms);
        }
    }

   private:
    Port& io;
    Dose active{};
    int slot = 1;
    bool manual = false, released = false;
    uint32_t since = 0;
    // Lectura: Anota el inicio y calcula el destino absoluto; el adaptador hará el movimiento
    // progresivo.
    void beginMove(uint32_t ms) {
        since = ms;
        // NEMA 17/TB6600: destino absoluto = compartimento × pasos/vuelta ÷ espacios.
        // Con cinco espacios y 3200 pasos: 640, 1280, 1920 y 2560; después retorna a cero.
        exitDetected = false;
        io.move(slot * STEPS_PER_TURN / positions);
        state = State::Outward;
    }
    // Lectura: Centraliza el registro durable: una escritura fallida bloquea las entregas
    // posteriores.
    bool log(const char* kind, int64_t epoch) {
        if (io.record(active, kind, epoch)) {
            lastEvent = kind;
            return true;
        }
        state = State::Fault;
        return false;
    }
};
inline bool validDose(const Dose& d, int positions = 4);
// Lectura: Valida ID, compartimento y rango de fecha antes de aceptar un horario desde JSON.
inline bool validDose(const Dose& d, int positions) {
    size_t n = strlen(d.id);
    if (n < 1 || n > 36 || d.compartment < 1 || d.compartment >= positions ||
        (positions != 4 && positions != 5) || d.scheduledAt < 1700000000000LL ||
        d.scheduledAt > 4102444800000LL)
        return false;
    for (size_t i = 0; i < n; i++)
        if (!((d.id[i] >= 'a' && d.id[i] <= 'z') || (d.id[i] >= 'A' && d.id[i] <= 'Z') ||
              (d.id[i] >= '0' && d.id[i] <= '9') || d.id[i] == '-'))
            return false;
    return true;
}
}  // namespace pill

namespace pill {
inline bool planModeMatches(const char* mode, bool simulation);
// Lectura: Un plan simulation solo sirve en simulación; un plan hardware solo en la variante
// física.
inline bool planModeMatches(const char* mode, bool simulation) {
    return mode && !strcmp(mode, simulation ? "simulation" : "hardware");
}
// PING observa la conexión y APPLY_PLAN comprueba una revisión: ninguno mueve el motor ni confirma
// tomas.
inline const char* commandDecision(const char* type, const char* mode, bool simulation,
                                   int64_t requested, int64_t expires, int64_t now, int revision,
                                   int applied);
inline const char* commandDecision(const char* type, const char* mode, bool simulation,
                                   int64_t requested, int64_t expires, int64_t now, int revision,
                                   int applied) {
    // Lectura: strcmp devuelve cero si ambos textos coinciden; otro modo se rechaza sin ejecutar el
    // comando.
    if (strcmp(mode, simulation ? "simulation" : "hardware"))
        return "WRONG_MODE";
    if (now < 1700000000000LL || requested > now + 60000 || expires <= requested ||
        // Lectura: El comando dura como máximo diez minutos y debe seguir vigente al procesarse.
        expires - requested > 600000 || expires <= now)
        return "EXPIRED_OR_INVALID_TIME";
    if (!strcmp(type, "PING"))
        return revision == 0 ? "OK" : "INVALID_REVISION";
    if (!strcmp(type, "APPLY_PLAN")) {
        if (revision < 1)
            return "INVALID_REVISION";
        // Lectura: APPLY_PLAN espera hasta que el firmware haya aplicado esa revisión o una
        // posterior.
        return applied >= revision ? "OK" : "WAIT";
    }
    // Lectura: Solo se admiten PING y APPLY_PLAN; no existe una orden remota de movimiento ni de
    // confirmación.
    return "UNKNOWN_COMMAND";
}
}  // namespace pill

#ifndef PASTILLERO_HOST_TEST
// Instancias reales: se declaran después de definir sus tipos; ninguna activa GPIO al construirse.
// El constructor no configura GPIO: la simulación debe ser inerte incluso antes de setup().
// Lectura: DRIVER usa PUL/DIR. false evita habilitar GPIO en el constructor, incluso antes de
// setup().
AccelStepper motor(AccelStepper::DRIVER, PIN_PUL, PIN_DIR, 0, 0, false);
// Lectura: Acceso a NVS: memoria flash que conserva reservas y pendientes al reiniciar el ESP32.
Preferences memoriaPersistente;
// Lectura: Copia en RAM de plan, IDs consumidos, entrega activa y colas pendientes; guardar la
// vuelve durable.
JsonDocument registroLocal;
// Lectura: Dos colas separan la tarea de red del control; no comparten un JsonDocument mutable.
QueueHandle_t mensajesEntrantes, mensajesSalientes;
struct MensajeRed {
    // Lectura: Puntero al texto duplicado: quien recibe el mensaje debe liberarlo después de
    // analizarlo.
    char* text;
};
bool almacenamientoDisponible = true;
long posicionSimulada = 0;
uint32_t ultimaTelemetria = 0;
pill::PeripheralSettings preferencias;
pill::Feedback indicadores;
pill::ExitDetector detectorSalida;
bool confirmacionReciente = false;
bool falloPerifericos = false;
struct TextoPantalla {
    char first[17], second[17];
};
QueueHandle_t mensajesPantalla = nullptr;

// Prototipos: anuncian funciones que se explican y definen más abajo.
int64_t obtenerHoraUtcMs();
bool guardarEstadoPersistente();
bool encolarMensaje(QueueHandle_t q, const String& text);
bool validarPlanRecibido(JsonVariantConst plan, pill::Dose* list, int& count);
void aplicarPreferencias(JsonVariantConst plan);
void procesarMensajesDeRed();
String solicitudHttps(const String& url, const String& method, const String& body, int& code,
                      const String& contentType = "application/json");
void mantenerSesionFirebase(String& token, String& refresh, uint32_t& refreshed, uint32_t ms);
void sincronizarConFirebase(String& token, JsonDocument& latest);
void tareaFirebase(void*);
bool leerBotonConfirmacion();
bool hayBlister();
void configurarMotorYSensores();
void restaurarMemoriaPersistente();
void prepararColasYRed();
void atenderCalibracionSerial(uint32_t ms);
bool leerSalidaPastilla(uint32_t ms);
void tareaPantalla(void*);
void actualizarIndicadores(uint32_t ms);
void enviarTelemetria(uint32_t ms);
void atenderDispensacion(uint32_t ms);
class AdaptadorMotor : public pill::Port {
   public:
    // Lectura: Adaptador del destino: en simulación solo cambia una variable; en hardware llama
    // moveTo().
    void move(long position) override {
#if PASTILLERO_DRY_RUN
        posicionSimulada = position;
        Serial.printf("SIMULACION destino: %ld\n", position);
#else
        motor.moveTo(position);
#endif
    }
    // Lectura: En simulación el destino llega inmediatamente; en hardware exige distanceToGo()==0.
    bool reached() override {
#if PASTILLERO_DRY_RUN
        return true;
#else
        return motor.distanceToGo() == 0;
#endif
    }
    // Lectura: Busca el ID en done: retransmitir el plan no vuelve a habilitar una dosis consumida.
    bool handled(const char* id) override {
        return !registroLocal["done"][id].isNull();
    }
    // Lectura: Construye un evento con clave estable y guarda la reserva antes de devolver éxito.
    bool record(const pill::Dose& d, const char* kind, int64_t actual) override {
        bool starting = strcmp(kind, "STARTED") == 0;
        if (!almacenamientoDisponible || registroLocal["events"].size() >= 64 ||
            (starting &&
             // Lectura: Reserva margen para terminar/recuperar una entrega; una memoria llena
             // requiere mantenimiento, Lectura: no borrar IDs.
             (registroLocal["events"].size() > 60 || registroLocal["done"].size() >= 256)))
            return false;
        // Lectura: La misma dosis y tipo producen la misma clave; SIM separa eventos de prueba de
        // los físicos.
        String key = String(d.id) + (PASTILLERO_DRY_RUN ? "-SIM-" : "-") + kind;
        auto e = registroLocal["events"][key].to<JsonObject>();
        pill::writeDoseEvent(e, d, kind, actual, bool(PASTILLERO_DRY_RUN));
        // Lectura: Marca durable de consumo, incluso si el evento sigue esperando Internet.
        pill::reserveDoseId(registroLocal, d);
        if (starting)
            // Lectura: STARTED deja evidencia de entrega en curso para detectar un reinicio
            // interrumpido.
            registroLocal["active"].set(e);
        else
            // Lectura: Al terminar con un evento final retira la entrega activa, conservando el ID
            // consumido.
            registroLocal.remove("active");
        if (!guardarEstadoPersistente())
            return false;
        Serial.printf("Evento durable: %s\n", kind);
        return true;
    }
} dispositivo;
pill::Controller controlador(dispositivo);

// Datos Wi-Fi del cliente viven en NVS del ESP32, nunca en Firebase ni en el sketch público.
std::atomic<bool> wifiConfigurando{false}, wifiSolicitada{false}, wifiRecibida{false}, wifiFallo{false};
Preferences memoriaWifi;
char codigoWifi[25] = {}, nombreWifi[24] = {};
uint32_t inicioWifi = 0, exitoWifi = 0;
bool gestorWifi = false, wifiPersistencia = false;
void inicializarWifiDinamico();
void atenderWifiDinamico(uint32_t ms);
void solicitarWifiLocal(bool mostrarCodigo);
void atenderBotonWifi(uint32_t ms);

// ============================================================
// 9. SETUP: INICIALIZACION UNA SOLA VEZ
// ============================================================
// Inicializa consola, geometría, periféricos permitidos, recuperación local y tarea de red una sola vez.
void setup() {
    Serial.begin(115200);
    controlador.geometry(DEFAULT_POSITIONS);
    configurarMotorYSensores();
    restaurarMemoriaPersistente();
    prepararColasYRed();
    Serial.println(
        "a/r: +/-10 pasos; c: confirmar cero; s: secuencia 1,2,3,4 y regreso a cero. SIMULACION por defecto.");
}


// ============================================================
// 10. LOOP: CICLO NO BLOQUEANTE
// ============================================================
// Atiende un paso del motor, mensajes seguros, calibración, dosis e indicadores sin esperar por la nube.
void loop() {
#if !PASTILLERO_DRY_RUN
    // Lectura: Genera el siguiente paso cuando corresponde; debe llamarse con frecuencia para
    // respetar velocidad y Lectura: aceleración.
    motor.run();
#endif
    // Lectura: Captura tiempo desde el arranque para intervalos; nunca se compara directamente con
    // una fecha Unix.
    uint32_t ms = millis();
    // Guardar en flash y recibir planes solo con el motor detenido evita interrumpir los pulsos.
    bool sincronizacionSegura =
        controlador.state == pill::State::Idle || controlador.state == pill::State::Awaiting ||
        controlador.state == pill::State::Alert || controlador.state == pill::State::Fault;
    if (dispositivo.reached() && mensajesEntrantes && sincronizacionSegura)
        procesarMensajesDeRed();
    atenderBotonWifi(ms);
    if (!wifiConfigurando.load()) atenderCalibracionSerial(ms);
    else if (Serial.available()) { char input = Serial.read(); if (input == 'w') solicitarWifiLocal(true); }
    // Lectura: Entrega al modelo una instantánea de tiempo y sensores; el modelo decide la
    // siguiente transición.
    if (!wifiConfigurando.load()) atenderDispensacion(ms);
    actualizarIndicadores(ms);
    enviarTelemetria(ms);
}


// ============================================================
// 11. FUNCIONES WIFI Y FIREBASE
// ============================================================
class RespuestaLimitada : public Stream {
   public:
    String value;
    int available() override {
        return 0;
    }
    int read() override {
        return -1;
    }
    int peek() override {
        return -1;
    }
    void flush() override {
    }
    size_t write(uint8_t c) override {
        return write(&c, 1);
    }
    size_t write(const uint8_t* data, size_t n) override {
        // Lectura: El límite también se comprueba al recibir por fragmentos, aunque el servidor no
        // indique tamaño Lectura: total.
        if (value.length() + n > 48000)
            return 0;
        return value.concat(reinterpret_cast<const char*>(data), n) ? n : 0;
    }
};
// Envía una solicitud HTTPS con raíces verificadas, tiempos máximos y respuesta de tamaño limitado.
String solicitudHttps(const String& url, const String& method, const String& body, int& code,
                      const String& contentType) {
    WiFiClientSecure tls;
    // Lectura: Verifica la cadena TLS del servidor mediante raíces públicas; no se usa
    // setInsecure().
    tls.setCACert(GOOGLE_ROOTS);
    // Lectura: Limita a ocho segundos la negociación TLS en la tarea de red separada.
    tls.setHandshakeTimeout(8);
    HTTPClient http;
    http.setConnectTimeout(5000);
    http.setTimeout(5000);
    if (!http.begin(tls, url)) {
        code = -1;
        return "";
    }
    http.addHeader("Content-Type", contentType);
    // Lectura: GET consulta, POST autentica y PUT publica; code recibe el estado HTTP, no el cuerpo
    // JSON.
    code = http.sendRequest(method.c_str(), body);
    RespuestaLimitada result;
    if (code > 0 && http.getSize() <= 48000) {
        // Lectura: Un fallo o exceso de tamaño invalida la respuesta; no se interpreta un JSON
        // truncado como éxito.
        if (http.writeToStream(&result) < 0) {
            code = -2;
            result.value = "";
        }
    } else {
        code = -2;
    }
    // Lectura: Libera la conexión HTTPS antes de devolver el cuerpo recibido.
    http.end();
    return result.value;
}

// Inicia sesión o renueva el token de la cuenta ordinaria; no almacena credenciales administrativas.
void mantenerSesionFirebase(String& token, String& refresh, uint32_t& refreshed, uint32_t ms) {
    int code;
    // Lectura: Autentica si falta token o han pasado unos cincuenta minutos; el token no se guarda
    // en el APK.
    if (token.isEmpty() || uint32_t(ms - refreshed) > 3000000) {
        String result;
        if (refresh.isEmpty()) {
            JsonDocument login;
            login["email"] = DEVICE_EMAIL;
            login["password"] = DEVICE_PASSWORD;
            // Lectura: Solicita un ID token y un refresh token de Firebase Authentication, con
            // privilegios del Lectura: dispositivo.
            login["returnSecureToken"] = true;
            String body;
            serializeJson(login, body);
            result = solicitudHttps(
                String(
                    "https://identitytoolkit.googleapis.com/v1/accounts:signInWithPassword?key=") +
                    FIREBASE_API_KEY,
                "POST", body, code);
        } else {
            result = solicitudHttps(
                String("https://securetoken.googleapis.com/v1/token?key=") + FIREBASE_API_KEY,
                "POST", String("grant_type=refresh_token&refresh_token=") + refresh, code,
                "application/x-www-form-urlencoded");
        }
        JsonDocument auth;
        if (code == 200 && !deserializeJson(auth, result)) {
            token = auth["idToken"].isNull() ? (auth["id_token"] | "") : (auth["idToken"] | "");
            refresh = auth["refreshToken"].isNull() ? (auth["refresh_token"] | "")
                                                    : (auth["refreshToken"] | "");
            refreshed = ms;
        } else {
            token = "";
            refresh = "";
        }
    }
}

// Consulta el programa y solicitudes; publica eventos y resultados con claves estables y acuses.
void sincronizarConFirebase(String& token, JsonDocument& latest) {
    int code;
    if (!token.isEmpty()) {
        String base = String(FIREBASE_DATABASE_URL) + "/devices/" + DEVICE_ID + "/v2";
        String auth = String(".json?auth=") + token;
        String plan = solicitudHttps(base + "/program" + auth, "GET", "", code);
        if (code == 200 && plan != "null")
            encolarMensaje(mensajesEntrantes, String("{\"plan\":") + plan + "}");
        // Lectura: Una sesión inválida vacía el token para volver a autenticar; no se recurre a
        // acceso público.
        if (code == 401)
            token = "";
        // Leer solo solicitudes y resultados recientes limita memoria y tráfico.
        String commands = solicitudHttps(
            base + "/commandRequests" + auth + "&orderBy=%22requestedAt%22&limitToLast=32", "GET",
            "", code);
        JsonDocument requests;
        if (code == 200)
            deserializeJson(requests, commands);
        String mode = PASTILLERO_DRY_RUN ? "simulation" : "hardware";
        String results = solicitudHttps(
            base + "/commandResults/" + mode + auth + "&orderBy=%22executedAt%22&limitToLast=64",
            "GET", "", code);
        JsonDocument completed;
        if (code == 200)
            deserializeJson(completed, results);
        if (code == 200)
            for (JsonPair entry : requests.as<JsonObject>()) {
                if (!completed[entry.key()].isNull() ||
                    !latest["commandResults"][entry.key()].isNull())
                    continue;
                JsonDocument message;
                message["commandId"] = entry.key().c_str();
                message["command"].set(entry.value());
                String text;
                serializeJson(message, text);
                encolarMensaje(mensajesEntrantes, text);
            }
        // Lectura: Reintenta cada resultado con su misma clave; solo retira el pendiente después de
        // HTTP 200.
        for (JsonPair entry : latest["commandResults"].as<JsonObject>()) {
            String body;
            serializeJson(entry.value(), body);
            solicitudHttps(base + "/commandResults/" + mode + "/" + entry.key().c_str() + auth,
                           "PUT", body, code);
            if (code == 200)
                encolarMensaje(mensajesEntrantes,
                               String("{\"commandAck\":\"") + entry.key().c_str() + "\"}");
            else
                break;
        }
        // Lectura: Reenvía eventos durables conservando ID y contenido; las reglas permiten
        // únicamente la repetición Lectura: idéntica.
        for (JsonPair e : latest["events"].as<JsonObject>()) {
            String body;
            serializeJson(e.value(), body);
            solicitudHttps(base + "/events/" + e.key().c_str() + auth, "PUT", body, code);
            if (code == 200)
                encolarMensaje(mensajesEntrantes, String("{\"ack\":\"") + e.key().c_str() + "\"}");
            else
                break;
        }
        if (!latest["state"].isNull()) {
            String body;
            serializeJson(latest["state"], body);
            solicitudHttps(base + "/state" + auth, "PUT", body, code);
        }
    }
}

// Aísla Wi-Fi, autenticación y red en otra tarea; recibe instantáneas mediante colas.
void tareaFirebase(void*) {
    String token, refresh;
    uint32_t refreshed = 0, attempt = 0, wifiAttempt = 0, backoff = 5000;
    JsonDocument latest;
    for (;;) {
        // Lectura: Captura tiempo desde el arranque para intervalos; nunca se compara directamente
        // con una fecha Unix.
        uint32_t ms = millis();
        atenderWifiDinamico(ms);
        if (wifiConfigurando.load()) { vTaskDelay(pdMS_TO_TICKS(20)); continue; }
        if (WiFi.status() != WL_CONNECTED && uint32_t(ms - wifiAttempt) >= backoff) {
            wifiAttempt = ms;
            // Sin literales SSID/password: el driver usa la última red aceptada en NVS.
            WiFi.begin();
            // Lectura: Espacia los reintentos Wi-Fi hasta un máximo de sesenta segundos para no
            // saturar la red.
            backoff = min(backoff * 2, uint32_t(60000));
        }
        MensajeRed m;
        while (xQueueReceive(mensajesSalientes, &m, 0) == pdTRUE) {
            deserializeJson(latest, m.text);
            free(m.text);
        }
        if (WiFi.status() == WL_CONNECTED && obtenerHoraUtcMs() > 1700000000000LL &&
            strlen(FIREBASE_API_KEY) && strlen(FIREBASE_DATABASE_URL) && uint32_t(ms - attempt) >= 5000) {
            attempt = ms;
            backoff = 5000;
            mantenerSesionFirebase(token, refresh, refreshed, ms);
            sincronizarConFirebase(token, latest);
        }
        // Lectura: Cede CPU veinte milisegundos solo en la tarea de red; loop sigue atendiendo el
        // motor.
        vTaskDelay(pdMS_TO_TICKS(20));
    }
}

// Crea colas y tareas, activa estación Wi-Fi y solicita sincronización UTC mediante NTP.
void prepararColasYRed() {
    mensajesEntrantes = xQueueCreate(8, sizeof(MensajeRed));
    mensajesSalientes = xQueueCreate(2, sizeof(MensajeRed));
    if (!mensajesEntrantes || !mensajesSalientes) {
        controlador.state = pill::State::Fault;
        return;
    }
#if !PASTILLERO_DRY_RUN
    if (PASTILLERO_LCD_AVAILABLE) {
        mensajesPantalla = xQueueCreate(1, sizeof(TextoPantalla));
        if (!mensajesPantalla ||
            xTaskCreatePinnedToCore(tareaPantalla, "lcd", 4096, nullptr, 1, nullptr, 0) != pdPASS)
            controlador.state = pill::State::Fault;
    }
#endif
    WiFi.persistent(true);
    WiFi.mode(WIFI_STA);
    WiFi.setAutoReconnect(true);
    inicializarWifiDinamico();
    // Lectura: Configura NTP en UTC, sin desplazamiento horario; Android convierte su selección
    // local a época Unix.
    configTime(0, 0, "time.google.com", "pool.ntp.org");
    if (xTaskCreatePinnedToCore(tareaFirebase, "firebase", 16384, nullptr, 1, nullptr, 0) != pdPASS)
        controlador.state = pill::State::Fault;
}


// Inicializa sin borrar historial ni configuración de dosis. Un cambio interrumpido vuelve a la red anterior.
void inicializarWifiDinamico() {
    wifiPersistencia = memoriaWifi.begin("wifi-setup", false);
    if (!wifiPersistencia) { Serial.println("No se pudo abrir la memoria Wi-Fi"); return; }
    if (memoriaWifi.getBytesLength("rollback") == sizeof(wifi_config_t)) {
        wifi_config_t anterior{};
        if (memoriaWifi.getBytes("rollback", &anterior, sizeof(anterior)) != sizeof(anterior) ||
            esp_wifi_set_config(WIFI_IF_STA, &anterior) != ESP_OK) {
            wifiPersistencia = false; return;
        }
        memoriaWifi.remove("rollback");
    }
    if (memoriaWifi.getString("code", "").length() != 24) {
        uint8_t random[12]; esp_fill_random(random, sizeof(random));
        for (size_t i = 0; i < sizeof(random); i++) snprintf(codigoWifi + i*2, 3, "%02x", random[i]);
        if (memoriaWifi.putString("code", codigoWifi) != 24) { wifiPersistencia = false; return; }
    } else memoriaWifi.getString("code", codigoWifi, sizeof(codigoWifi));
    uint8_t mac[6]{}; esp_wifi_get_mac(WIFI_IF_STA, mac);
    snprintf(nombreWifi, sizeof(nombreWifi), "BADI_SETUP_%02X%02X%02X", mac[3], mac[4], mac[5]);
    wifi_config_t actual{};
    if (esp_wifi_get_config(WIFI_IF_STA, &actual) == ESP_OK && actual.sta.ssid[0]) WiFi.begin();
    else if (pill::wifiSetupAllowed(controlador.state, dispositivo.reached())) {
        wifiConfigurando = true; wifiSolicitada = true;
    }
}
// El código se obtiene una vez por USB para la etiqueta; no es la contraseña del router.
// Nunca se imprime durante el arranque ni se envía a Firebase. No ejecutar w automáticamente en QA.
void solicitarWifiLocal(bool mostrarCodigo) {
    if (!wifiPersistencia || (!wifiConfigurando && !pill::wifiSetupAllowed(controlador.state, dispositivo.reached()))) {
        Serial.println("Wi-Fi: espere a reposo y revise memoria"); return;
    }
    if (mostrarCodigo) Serial.printf("ETIQUETA LOCAL: %s / %s\n", nombreWifi, codigoWifi);
    if (!wifiConfigurando) { wifiConfigurando = true; wifiSolicitada = true; }
}
void atenderBotonWifi(uint32_t ms) {
    static bool armed = false, timing = false;
    static uint32_t since = 0;
    bool pressed = false;
#if !PASTILLERO_DRY_RUN
    pressed = digitalRead(PIN_BUTTON) == LOW;
#endif
    bool idle = !wifiConfigurando && pill::wifiSetupAllowed(controlador.state, dispositivo.reached());
    if (pill::wifiButtonRequest(idle, pressed, ms, armed, timing, since)) solicitarWifiLocal(false);
}
// Solo la tarea de red toca el gestor/NVS Wi-Fi; loop no espera conexiones ni escribe esas contraseñas.
void atenderWifiDinamico(uint32_t ms) {
    if (wifiSolicitada.exchange(false)) {
        wifi_config_t anterior{};
        if (!wifiPersistencia || esp_wifi_get_config(WIFI_IF_STA, &anterior) != ESP_OK ||
            memoriaWifi.putBytes("rollback", &anterior, sizeof(anterior)) != sizeof(anterior)) {
            wifiConfigurando = false; Serial.println("Wi-Fi: no se pudo proteger la red anterior"); return;
        }
        WiFi.setAutoReconnect(false);
        WiFi.disconnect(false, false);
        network_prov_mgr_config_t config{};
        config.scheme = network_prov_scheme_softap;
        config.app_event_handler.event_cb = [](void*, network_prov_cb_event_t event, void*) {
            if (event == NETWORK_PROV_WIFI_CRED_SUCCESS) wifiRecibida = true;
            if (event == NETWORK_PROV_WIFI_CRED_FAIL) wifiFallo = true;
        };
        inicioWifi = ms; exitoWifi = 0; wifiRecibida = false; wifiFallo = false;
        gestorWifi = network_prov_mgr_init(config) == ESP_OK;
        if (gestorWifi) {
            network_prov_mgr_disable_auto_stop(1000);
            if (network_prov_mgr_start_provisioning(NETWORK_PROV_SECURITY_1, codigoWifi, nombreWifi, codigoWifi) != ESP_OK)
                inicioWifi = ms - 300000;
        } else inicioWifi = ms - 300000;
    }
    if (!wifiConfigurando) return;
    if (gestorWifi && wifiFallo.exchange(false)) network_prov_mgr_reset_wifi_sm_state_on_failure();
    if (wifiRecibida.load() && WiFi.status() == WL_CONNECTED && !exitoWifi) exitoWifi = ms ? ms : 1;
    bool success = exitoWifi && uint32_t(ms - exitoWifi) >= 10000;
    if (!success && !pill::wifiSetupExpired(ms, inicioWifi)) return;
    if (gestorWifi) { network_prov_mgr_stop_provisioning(); network_prov_mgr_deinit(); gestorWifi = false; }
    if (!success && memoriaWifi.getBytesLength("rollback") == sizeof(wifi_config_t)) {
        wifi_config_t anterior{};
        if (memoriaWifi.getBytes("rollback", &anterior, sizeof(anterior)) != sizeof(anterior) ||
            esp_wifi_set_config(WIFI_IF_STA, &anterior) != ESP_OK) {
            Serial.println("Wi-Fi: recuperación pendiente; configuración retenida"); return;
        }
    }
    if (!memoriaWifi.remove("rollback")) { Serial.println("Wi-Fi: no se confirmó persistencia"); return; }
    WiFi.mode(WIFI_STA); WiFi.setAutoReconnect(true);
    if (!success) WiFi.begin();
    wifiConfigurando = false;
    Serial.println(success ? "Wi-Fi: nueva red aceptada" : "Wi-Fi: cambio cancelado, red anterior recuperada");
}

// ============================================================
// 12. FUNCIONES DEL MOTOR Y CALIBRACION
// ============================================================
// Configura GPIO y AccelStepper únicamente en la variante física; respeta bloqueos de periféricos.
void configurarMotorYSensores() {
#if !PASTILLERO_DRY_RUN
    motor.enableOutputs();
    pinMode(PIN_BUTTON, INPUT_PULLUP);
    pinMode(PIN_BUZZER, OUTPUT);
    pinMode(PIN_READY, OUTPUT);
    pinMode(PIN_ALERT, OUTPUT);
    // Lectura: Conserva inversión de DIR y STEP del montaje original; no altera la secuencia de
    // compartimentos.
    motor.setPinsInverted(true, true);
    // Lectura: Fija un pulso mínimo de diez microsegundos; verificar compatibilidad del módulo
    // TB6600 real.
    motor.setMinPulseWidth(10);
    // Lectura: Límite de velocidad: mil pasos por segundo, no revoluciones por minuto.
    motor.setMaxSpeed(1000);
    // Lectura: Aceleración de quinientos pasos por segundo al cuadrado para los movimientos
    // progresivos.
    motor.setAcceleration(500);
    if (PASTILLERO_EXIT_AVAILABLE)
        pinMode(PIN_EXIT, INPUT);
    if (PASTILLERO_PUMP_AVAILABLE) {
        pinMode(PIN_PUMP, OUTPUT);
        digitalWrite(PIN_PUMP, LOW);
    }
    if (PASTILLERO_SERVO_AVAILABLE && !ledcAttach(PIN_SERVO, 50, 16)) {
        falloPerifericos = true;
        controlador.state = pill::State::Fault;
    }
#endif
}

// Interpreta a/r/c/s solo con el motor detenido; fija cero y conserva el recorrido por compartimentos.
void atenderCalibracionSerial(uint32_t ms) {
    if (Serial.available()) {
        char c = Serial.read();
        if (c == 'w') { solicitarWifiLocal(true); return; }
        if (!controlador.busy() && dispositivo.reached()) {
            // Lectura: Antes de c, a suma diez pasos y r resta diez; no gira una vuelta completa.
            if (!controlador.calibrated && (c == 'a' || c == 'r')) {
#if PASTILLERO_DRY_RUN
                dispositivo.move(posicionSimulada + (c == 'a' ? 10 : -10));
#else
                dispositivo.move(motor.currentPosition() + (c == 'a' ? 10 : -10));
#endif
                // Lectura: c fija como cero la posición actual una sola vez por arranque; no busca
                // un final de carrera.
            } else if (c == 'c' && !controlador.calibrated) {
#if !PASTILLERO_DRY_RUN
                // Lectura: Renombra la posición actual como cero sin movimiento físico.
                motor.setCurrentPosition(0);
#endif
                posicionSimulada = 0;
                controlador.calibrated = true;
                Serial.println("Punto 0 confirmado");
                // Lectura: s inicia la secuencia manual calibrada; no es un comando recibido desde
                // Android.
            } else if (c == 's')
                controlador.manualStart(ms);
        }
    }
}


// ============================================================
// 13. FUNCIONES DE DISPENSACION
// ============================================================
// Controller.tick, definido en la sección 8, es la misma máquina de estados probada en PC.
void atenderDispensacion(uint32_t ms) {
    auto previous = controlador.state;
    if (!indicadores.pump)
        controlador.tick(ms, obtenerHoraUtcMs(), hayBlister(), leerBotonConfirmacion(),
                         leerSalidaPastilla(ms));
    confirmacionReciente =
        previous == pill::State::Awaiting && controlador.state == pill::State::Idle;
}

// ============================================================
// 14. FUNCIONES DE SENSORES
// ============================================================
// Devuelve una pulsación filtrada por estabilidad; en simulación no consulta GPIO.
bool leerBotonConfirmacion() {
#if PASTILLERO_DRY_RUN
    return false;
#else
    static bool raw = false, stable = false;
    static uint32_t changed = 0;
    // Lectura: INPUT_PULLUP hace que pulsar contra GND sea LOW; now=true significa botón
    // presionado.
    bool now = digitalRead(PIN_BUTTON) == LOW;
    if (now != raw) {
        raw = now;
        changed = millis();
    }
    if (uint32_t(millis() - changed) >= 40)
        stable = raw;
    return stable;
#endif
}

// Comprueba presencia mediante el umbral óptico; no equivale al sensor de salida ni a ingestión.
bool hayBlister() {
#if PASTILLERO_DRY_RUN
    return true;
#else
    return analogRead(PIN_OPTICAL) >= OPTICAL_THRESHOLD;
#endif
}

// Filtra el sensor de salida independiente; en simulación aporta una entrada ficticia controlada.
bool leerSalidaPastilla(uint32_t ms) {
#if PASTILLERO_DRY_RUN
    return false;
#else
    return PASTILLERO_EXIT_AVAILABLE && preferencias.exitSensorEnabled &&
           detectorSalida.sample(digitalRead(PIN_EXIT) == LOW, ms);
#endif
}


// ============================================================
// 15. FUNCIONES DE ALERTAS, LCD Y PERIFERICOS
// ============================================================
class Pantalla16x2 {
    void expander(uint8_t value) {
        Wire.beginTransmission(LCD_ADDRESS);
        Wire.write(value | 0x08);
        Wire.endTransmission();
    }
    void nibble(uint8_t value) {
        expander(value | 0x04);
        delayMicroseconds(1);
        expander(value & ~0x04);
        delayMicroseconds(50);
    }
    void send(uint8_t value, bool data) {
        uint8_t rs = data ? 1 : 0;
        nibble((value & 0xf0) | rs);
        nibble((value << 4) | rs);
    }

   public:
    void begin() {
        Wire.begin(PIN_SDA, PIN_SCL);
        Wire.setTimeOut(20);
        vTaskDelay(pdMS_TO_TICKS(50));
        nibble(0x30);
        vTaskDelay(pdMS_TO_TICKS(5));
        nibble(0x30);
        nibble(0x30);
        nibble(0x20);
        send(0x28, false);
        send(0x0c, false);
        send(0x06, false);
    }
    void line(int row, const char* text) {
        send(row ? 0xc0 : 0x80, false);
        for (int i = 0; i < 16; i++)
            send(i < int(strlen(text)) ? text[i] : ' ', true);
    }
};
// Actualiza el LCD por I2C desde una cola separada para no detener los pulsos del motor.
void tareaPantalla(void*) {
#if !PASTILLERO_DRY_RUN
    Pantalla16x2 lcd;
    bool initialized = false;
    TextoPantalla text;
    for (;;) {
        if (xQueueReceive(mensajesPantalla, &text, pdMS_TO_TICKS(500)) == pdTRUE) {
            if (!initialized) {
                lcd.begin();
                initialized = true;
            }
            lcd.line(0, text.first);
            lcd.line(1, text.second);
        }
    }
#else
    vTaskDelete(nullptr);
#endif
}

// Calcula avisos, servo y bomba; aplica preferencias sin saltar las disponibilidades locales.
void actualizarIndicadores(uint32_t ms) {
    indicadores.tick(controlador.state, ms, confirmacionReciente, preferencias);
#if !PASTILLERO_DRY_RUN
    digitalWrite(PIN_ALERT, indicadores.alert);
    digitalWrite(PIN_READY, indicadores.ready);
    digitalWrite(PIN_BUZZER, indicadores.buzzer);
    if (PASTILLERO_PUMP_AVAILABLE)
        digitalWrite(PIN_PUMP, indicadores.pump ? HIGH : LOW);
    if (PASTILLERO_SERVO_AVAILABLE)
        ledcWrite(PIN_SERVO, preferencias.servoEnabled
                                 ? (indicadores.servoOpen ? SERVO_OPEN_US : SERVO_CLOSED_US) *
                                       65535UL / 20000UL
                                 : 0);
#endif
    static int last = -1;
    static uint32_t printed = 0;
    if (preferencias.lcdEnabled &&
        (last != int(controlador.state) || uint32_t(ms - printed) >= 2000)) {
        last = int(controlador.state);
        printed = ms;
        TextoPantalla text;
        pill::Feedback::lcd(controlador.state, controlador.currentCompartment(), PASTILLERO_DRY_RUN,
                            text.first, text.second, controlador.lastEvent);
        if (indicadores.confirmationVisible) {
            snprintf(text.first, sizeof(text.first), "Toma confirmada");
            snprintf(text.second, sizeof(text.second), "Aviso apagado");
        }
#if PASTILLERO_DRY_RUN
        Serial.printf("LCD SIM: [%s] [%s]\n", text.first, text.second);
#else
        if (PASTILLERO_LCD_AVAILABLE && mensajesPantalla)
            xQueueOverwrite(mensajesPantalla, &text);
#endif
    }
}


// ============================================================
// 16. FUNCIONES DE CALENDARIO Y VALIDACION DE HORARIOS
// ============================================================
// Android expande semana/intervalos a UTC; el ESP32 compara estas fechas sin esperar ni reconstruir pautas.
// Convierte segundos UTC a milisegundos para comparar horarios; millis se reserva a intervalos.
int64_t obtenerHoraUtcMs() {
    return int64_t(time(nullptr)) * 1000;
}

// Valida modo, geometría, campos, límites e identidades de todas las dosis antes de aceptar un plan.
bool validarPlanRecibido(JsonVariantConst plan, pill::Dose* list, int& count) {
    count = 0;
    if (!plan["version"].is<int>() || plan["version"].as<int>() != 2 ||
        !pill::planModeMatches(plan["targetMode"].as<const char*>(), PASTILLERO_DRY_RUN))
        return false;
    int positions = plan["positions"] | 0;
    if ((positions != 4 && positions != 5) || !plan["revision"].is<int>() ||
        plan["revision"].as<int>() < 1 ||
        (!plan["doses"].isNull() && !plan["doses"].is<JsonObjectConst>()) ||
        plan["doses"].size() > 96)
        return false;
    auto settings = plan["settings"];
    const char* flags[] = {"ledEnabled",        "buzzerEnabled", "lcdEnabled",
                           "exitSensorEnabled", "servoEnabled",  "pumpEnabled"};
    for (const char* flag : flags)
        if (!settings[flag].is<bool>())
            return false;
    if (!settings["positions"].is<int>() || settings["positions"].as<int>() != positions ||
        !settings["pumpDurationMs"].is<int>() || settings["pumpDurationMs"].as<int>() < 500 ||
        settings["pumpDurationMs"].as<int>() > 5000)
        return false;
#if !PASTILLERO_DRY_RUN
    if ((settings["lcdEnabled"].as<bool>() && !PASTILLERO_LCD_AVAILABLE) ||
        (settings["exitSensorEnabled"].as<bool>() && !PASTILLERO_EXIT_AVAILABLE) ||
        (settings["servoEnabled"].as<bool>() && !PASTILLERO_SERVO_AVAILABLE) ||
        (settings["pumpEnabled"].as<bool>() && !PASTILLERO_PUMP_AVAILABLE))
        return false;
#endif
    for (JsonPairConst pair : plan["doses"].as<JsonObjectConst>()) {
        auto value = pair.value();
        pill::Dose d;
        if (strlen(pair.key().c_str()) > 36 || !value["scheduledAt"].is<int64_t>() ||
            !value["compartment"].is<int>() || !value["medicationId"].is<const char*>())
            return false;
        const char* medication = value["medicationId"];
        if (strlen(medication) < 1 || strlen(medication) > 36)
            return false;
        strlcpy(d.id, pair.key().c_str(), sizeof(d.id));
        strlcpy(d.medicationId, value["medicationId"], sizeof(d.medicationId));
        d.scheduledAt = value["scheduledAt"];
        d.compartment = value["compartment"];
        if (!pill::validDose(d, positions))
            return false;
        pill::Dose check = d;
        strlcpy(check.id, medication, sizeof(check.id));
        if (!pill::validDose(check, positions))
            return false;
        auto old = registroLocal["plan"]["doses"][d.id];
        if (!old.isNull() && (old["scheduledAt"].as<int64_t>() != d.scheduledAt ||
                              old["compartment"].as<int>() != d.compartment))
            return false;
        list[count++] = d;
    }
    return true;
}


// ============================================================
// 17. FUNCIONES DE SINCRONIZACION Y PERSISTENCIA
// ============================================================
// Serializa y persiste el documento como blob; rechaza falta de memoria o escritura incompleta.
bool guardarEstadoPersistente() {
    if (registroLocal.overflowed()) {
        almacenamientoDisponible = false;
        return false;
    }
    String json;
    serializeJson(registroLocal, json);
    // Lectura: Limita el documento a 48 kB y compara bytes escritos; una copia incompleta no se
    // acepta.
    if (!pill::saveSnapshotBlob(memoriaPersistente, json.c_str(), json.length())) {
        almacenamientoDisponible = false;
        return false;
    }
    return true;
}

// Duplica el texto y lo entrega a una cola sin esperar; libera la copia si no hay espacio.
bool encolarMensaje(QueueHandle_t q, const String& text) {
    MensajeRed m{strdup(text.c_str())};
    if (!m.text)
        return false;
    // Lectura: Cero ticks de espera: una cola llena devuelve error y libera la copia, sin bloquear
    // el motor.
    if (xQueueSend(q, &m, 0) != pdTRUE) {
        free(m.text);
        return false;
    }
    return true;
}

// Aplica geometría y periféricos de un programa validado, conservando límites del dispositivo.
void aplicarPreferencias(JsonVariantConst plan) {
    controlador.geometry(plan["positions"] | 4);
    auto p = plan["settings"];
    preferencias.ledEnabled = p["ledEnabled"];
    preferencias.buzzerEnabled = p["buzzerEnabled"];
    preferencias.lcdEnabled = p["lcdEnabled"];
    preferencias.exitSensorEnabled = p["exitSensorEnabled"];
    preferencias.servoEnabled = p["servoEnabled"];
    preferencias.pumpEnabled = p["pumpEnabled"];
    preferencias.pumpDurationMs = p["pumpDurationMs"] | 2000;
    controlador.requireExit = preferencias.exitSensorEnabled;
}

// Procesa planes, comandos y acuses; solo instala un programa después de validarlo y persistirlo.
void procesarMensajesDeRed() {
    MensajeRed m;
    if (xQueueReceive(mensajesEntrantes, &m, 0) != pdTRUE)
        return;
    JsonDocument doc;
    // Lectura: Analiza JSON en el documento; ArduinoJson 7 copia las cadenas, por eso luego puede
    // liberarse m.text.
    auto err = deserializeJson(doc, m.text);
    free(m.text);
    if (err)
        return;
    if (doc["plan"].is<JsonObject>() &&
        !pill::planModeMatches(doc["plan"]["targetMode"].as<const char*>(), PASTILLERO_DRY_RUN)) {
        // Un cambio de modo retira horarios futuros almacenados: un plan simulado nunca se
        // reutiliza en hardware.
        if (controlador.count || !registroLocal["plan"].isNull()) {
            controlador.count = 0;
            registroLocal.remove("plan");
            if (!guardarEstadoPersistente())
                controlador.state = pill::State::Fault;
        }
        return;
    }
    // Lectura: Un acuse remoto permite retirar el resultado pendiente de NVS; no es un comando de
    // motor.
    if (doc["commandAck"].is<const char*>()) {
        registroLocal["commandResults"].remove(doc["commandAck"].as<const char*>());
        if (!guardarEstadoPersistente())
            controlador.state = pill::State::Fault;
    } else if (doc["commandId"].is<const char*>()) {
        const char* id = doc["commandId"];
        pill::Dose key;
        strlcpy(key.id, id, sizeof(key.id));
        key.scheduledAt = 1700000000000LL;
        if (strlen(id) > 36 || !pill::validDose(key) ||
            !registroLocal["commandResults"][id].isNull())
            return;
        auto command = doc["command"];
        if (!command["type"].is<const char*>() || !command["targetMode"].is<const char*>() ||
            !command["requestedAt"].is<int64_t>() || !command["expiresAt"].is<int64_t>() ||
            !command["planRevision"].is<int>())
            return;
        const char* reason =
            pill::commandDecision(command["type"], command["targetMode"], PASTILLERO_DRY_RUN,
                                  command["requestedAt"], command["expiresAt"], obtenerHoraUtcMs(),
                                  command["planRevision"], registroLocal["plan"]["revision"] | 0);
        // Otro modo deja pendiente la solicitud para el firmware al que realmente va dirigida.
        // Lectura: Mantiene pendientes los comandos aún no aplicables; no crea un rechazo
        // definitivo para otro modo.
        if (!strcmp(reason, "WAIT") || !strcmp(reason, "WRONG_MODE"))
            return;
        if (!almacenamientoDisponible || registroLocal["commandResults"].size() >= 16)
            return;
        auto result = registroLocal["commandResults"][id].to<JsonObject>();
        result["status"] = !strcmp(reason, "OK") ? "COMPLETED" : "REJECTED";
        result["reason"] = reason;
        result["executedAt"] = obtenerHoraUtcMs();
        result["requestedAt"] = command["requestedAt"];
        result["planRevision"] = registroLocal["plan"]["revision"] | 0;
        result["simulation"] = bool(PASTILLERO_DRY_RUN);
        if (!guardarEstadoPersistente())
            controlador.state = pill::State::Fault;
    } else if (doc["ack"].is<const char*>()) {
        const char* key = doc["ack"];
        if (!registroLocal["events"][key].isNull()) {
            // Lectura: Retira solo el pendiente ya confirmado por Firebase; done conserva la
            // prevención de duplicados.
            registroLocal["events"].remove(key);
            if (!guardarEstadoPersistente())
                controlador.state = pill::State::Fault;
        }
    } else if (!controlador.busy() && dispositivo.reached() &&
               doc["plan"]["revision"].as<int>() > registroLocal["plan"]["revision"].as<int>()) {
        std::unique_ptr<pill::Dose[]> parsed(new (std::nothrow) pill::Dose[96]);
        if (!parsed) {
            controlador.state = pill::State::Fault;
            return;
        }
        int count;
        if (!validarPlanRecibido(doc["plan"], parsed.get(), count)) {
            Serial.println("Plan rechazado por validacion");
            return;
        }
        registroLocal["plan"].set(doc["plan"]);
        if (!guardarEstadoPersistente()) {
            controlador.state = pill::State::Fault;
            return;
        }
        // Lectura: Después de persistir el plan válido, copia las dosis y actualiza count; no
        // cambia la dosis activa.
        aplicarPreferencias(doc["plan"]);
        memcpy(controlador.doses, parsed.get(), count * sizeof(pill::Dose));
        controlador.count = count;
    }
}

// Restaura reservas y pendientes, migra la cadena histórica y bloquea una recuperación inválida.
void restaurarMemoriaPersistente() {
    almacenamientoDisponible =
        memoriaPersistente.begin(PASTILLERO_DRY_RUN ? "pill-sim" : "pastillero", false);
    auto failed = []() {
        almacenamientoDisponible = false;
        controlador.state = pill::State::Fault;
    };
    if (!almacenamientoDisponible) { failed(); return; }
    auto source = pill::snapshotSource(memoriaPersistente);
    String stored;
    if (source == pill::SnapshotSource::Invalid) { failed(); return; }
    if (source == pill::SnapshotSource::Blob) {
        size_t length = pill::snapshotBlobSize(memoriaPersistente);
        if (!length) { failed(); return; }
        std::unique_ptr<char[]> bytes(new (std::nothrow) char[length + 1]);
        if (!bytes || !pill::readSnapshotBlob(memoriaPersistente, bytes.get(), length + 1, length)
            || !stored.concat(bytes.get(), length)) { failed(); return; }
    } else if (source == pill::SnapshotSource::LegacyString) {
        stored = memoriaPersistente.getString("snapshot", "");
        if (stored.isEmpty()) { failed(); return; }
    }
    // Una copia inválida no se normaliza ni se sobrescribe como si fuera un arranque nuevo.
    if (stored.length() && deserializeJson(registroLocal, stored)) { failed(); return; }
    if (stored.length() && (registroLocal["protocolVersion"] | 0) != 2) {
        // Copia recuperable en NVS antes de retirar solo el plan V1; done/eventos se conservan.
        // Otra clave conserva además las copias legacy-v1 antiguas sin sobrescribirlas.
        if (memoriaPersistente.putBytes("legacy-v1b", stored.c_str(), stored.length()) != stored.length()) {
            failed(); return;
        }
        registroLocal.remove("plan");
        registroLocal["protocolVersion"] = 2;
    }
    registroLocal["protocolVersion"] = 2;
    // Convierte la cadena anterior una sola vez; la conserva como copia recuperable, pero
    // el marcador impide reutilizarla automáticamente si se pierde el blob posterior.
    if (source == pill::SnapshotSource::LegacyString && !guardarEstadoPersistente()) {
        failed(); return;
    }
    if (!registroLocal["active"].isNull()) {
        pill::Dose d;
        strlcpy(d.id, registroLocal["active"]["doseId"] | "", sizeof(d.id));
        // La recuperación conserva también la pauta de origen; V1 puede no tener este campo.
        strlcpy(d.medicationId, registroLocal["active"]["medicationId"] | "", sizeof(d.medicationId));
        d.scheduledAt = registroLocal["active"]["scheduledAt"];
        d.compartment = registroLocal["active"]["compartment"];
        // Lectura: Registra interrupción conservando la reserva del ID; si no puede persistir,
        // bloquea el sistema.
        if (!dispositivo.record(d, "RECOVERY", obtenerHoraUtcMs()))
            almacenamientoDisponible = false;
        else {
            controlador.state = pill::State::Alert;
            controlador.lastEvent = "RECOVERY";
        }
    }
    if (!registroLocal["plan"].isNull() &&
        !validarPlanRecibido(registroLocal["plan"], controlador.doses, controlador.count))
        almacenamientoDisponible = false;
    if (!registroLocal["plan"].isNull() && almacenamientoDisponible)
        aplicarPreferencias(registroLocal["plan"]);
    if (!almacenamientoDisponible || falloPerifericos)
        controlador.state = pill::State::Fault;
}

// Crea una instantánea de estado y pendientes para la tarea de red cuando el motor está detenido.
void enviarTelemetria(uint32_t ms) {
    if (mensajesSalientes && dispositivo.reached() && uint32_t(ms - ultimaTelemetria) >= 2000) {
        ultimaTelemetria = ms;
        JsonDocument msg;
        msg["events"].set(registroLocal["events"]);
        msg["commandResults"].set(registroLocal["commandResults"]);
        auto state = msg["state"].to<JsonObject>();
        state["phase"] = int(controlador.state);
        state["protocolVersion"] = 2;
        state["positions"] = controlador.positions;
        state["exitDetected"] = controlador.exitDetected;
        state["pumpActive"] = indicadores.pump;
        state["servoOpen"] = indicadores.servoOpen;
        state["calibrated"] = controlador.calibrated;
        state["appliedRevision"] = registroLocal["plan"]["revision"] | 0;
        state["updatedAt"] = obtenerHoraUtcMs();
        state["simulation"] = bool(PASTILLERO_DRY_RUN);
        state["storageHealthy"] = almacenamientoDisponible;
        state["blisterPresent"] = hayBlister();
        String text;
        serializeJson(msg, text);
        encolarMensaje(mensajesSalientes, text);
    }
}


#endif // PASTILLERO_HOST_TEST
#endif // PASTILLERO_UNIFIED_SKETCH
